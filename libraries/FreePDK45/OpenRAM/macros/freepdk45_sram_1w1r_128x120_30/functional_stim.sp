* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/jp502/Projects/system-PPA/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "freepdk45_sram_1w1r_128x120_30.sp"

* Global Power Supplies
Vvdd vdd 0 0.9

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xfreepdk45_sram_1w1r_128x120_30 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 din0_33 din0_34 din0_35 din0_36 din0_37 din0_38 din0_39 din0_40 din0_41 din0_42 din0_43 din0_44 din0_45 din0_46 din0_47 din0_48 din0_49 din0_50 din0_51 din0_52 din0_53 din0_54 din0_55 din0_56 din0_57 din0_58 din0_59 din0_60 din0_61 din0_62 din0_63 din0_64 din0_65 din0_66 din0_67 din0_68 din0_69 din0_70 din0_71 din0_72 din0_73 din0_74 din0_75 din0_76 din0_77 din0_78 din0_79 din0_80 din0_81 din0_82 din0_83 din0_84 din0_85 din0_86 din0_87 din0_88 din0_89 din0_90 din0_91 din0_92 din0_93 din0_94 din0_95 din0_96 din0_97 din0_98 din0_99 din0_100 din0_101 din0_102 din0_103 din0_104 din0_105 din0_106 din0_107 din0_108 din0_109 din0_110 din0_111 din0_112 din0_113 din0_114 din0_115 din0_116 din0_117 din0_118 din0_119 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a1_0 a1_1 a1_2 a1_3 a1_4 a1_5 a1_6 CSB0 CSB1 clk0 clk1 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 dout1_32 dout1_33 dout1_34 dout1_35 dout1_36 dout1_37 dout1_38 dout1_39 dout1_40 dout1_41 dout1_42 dout1_43 dout1_44 dout1_45 dout1_46 dout1_47 dout1_48 dout1_49 dout1_50 dout1_51 dout1_52 dout1_53 dout1_54 dout1_55 dout1_56 dout1_57 dout1_58 dout1_59 dout1_60 dout1_61 dout1_62 dout1_63 dout1_64 dout1_65 dout1_66 dout1_67 dout1_68 dout1_69 dout1_70 dout1_71 dout1_72 dout1_73 dout1_74 dout1_75 dout1_76 dout1_77 dout1_78 dout1_79 dout1_80 dout1_81 dout1_82 dout1_83 dout1_84 dout1_85 dout1_86 dout1_87 dout1_88 dout1_89 dout1_90 dout1_91 dout1_92 dout1_93 dout1_94 dout1_95 dout1_96 dout1_97 dout1_98 dout1_99 dout1_100 dout1_101 dout1_102 dout1_103 dout1_104 dout1_105 dout1_106 dout1_107 dout1_108 dout1_109 dout1_110 dout1_111 dout1_112 dout1_113 dout1_114 dout1_115 dout1_116 dout1_117 dout1_118 dout1_119 vdd gnd freepdk45_sram_1w1r_128x120_30

* SRAM output loads
CD10 dout1_0  0 0.8364f
CD11 dout1_1  0 0.8364f
CD12 dout1_2  0 0.8364f
CD13 dout1_3  0 0.8364f
CD14 dout1_4  0 0.8364f
CD15 dout1_5  0 0.8364f
CD16 dout1_6  0 0.8364f
CD17 dout1_7  0 0.8364f
CD18 dout1_8  0 0.8364f
CD19 dout1_9  0 0.8364f
CD110 dout1_10  0 0.8364f
CD111 dout1_11  0 0.8364f
CD112 dout1_12  0 0.8364f
CD113 dout1_13  0 0.8364f
CD114 dout1_14  0 0.8364f
CD115 dout1_15  0 0.8364f
CD116 dout1_16  0 0.8364f
CD117 dout1_17  0 0.8364f
CD118 dout1_18  0 0.8364f
CD119 dout1_19  0 0.8364f
CD120 dout1_20  0 0.8364f
CD121 dout1_21  0 0.8364f
CD122 dout1_22  0 0.8364f
CD123 dout1_23  0 0.8364f
CD124 dout1_24  0 0.8364f
CD125 dout1_25  0 0.8364f
CD126 dout1_26  0 0.8364f
CD127 dout1_27  0 0.8364f
CD128 dout1_28  0 0.8364f
CD129 dout1_29  0 0.8364f
CD130 dout1_30  0 0.8364f
CD131 dout1_31  0 0.8364f
CD132 dout1_32  0 0.8364f
CD133 dout1_33  0 0.8364f
CD134 dout1_34  0 0.8364f
CD135 dout1_35  0 0.8364f
CD136 dout1_36  0 0.8364f
CD137 dout1_37  0 0.8364f
CD138 dout1_38  0 0.8364f
CD139 dout1_39  0 0.8364f
CD140 dout1_40  0 0.8364f
CD141 dout1_41  0 0.8364f
CD142 dout1_42  0 0.8364f
CD143 dout1_43  0 0.8364f
CD144 dout1_44  0 0.8364f
CD145 dout1_45  0 0.8364f
CD146 dout1_46  0 0.8364f
CD147 dout1_47  0 0.8364f
CD148 dout1_48  0 0.8364f
CD149 dout1_49  0 0.8364f
CD150 dout1_50  0 0.8364f
CD151 dout1_51  0 0.8364f
CD152 dout1_52  0 0.8364f
CD153 dout1_53  0 0.8364f
CD154 dout1_54  0 0.8364f
CD155 dout1_55  0 0.8364f
CD156 dout1_56  0 0.8364f
CD157 dout1_57  0 0.8364f
CD158 dout1_58  0 0.8364f
CD159 dout1_59  0 0.8364f
CD160 dout1_60  0 0.8364f
CD161 dout1_61  0 0.8364f
CD162 dout1_62  0 0.8364f
CD163 dout1_63  0 0.8364f
CD164 dout1_64  0 0.8364f
CD165 dout1_65  0 0.8364f
CD166 dout1_66  0 0.8364f
CD167 dout1_67  0 0.8364f
CD168 dout1_68  0 0.8364f
CD169 dout1_69  0 0.8364f
CD170 dout1_70  0 0.8364f
CD171 dout1_71  0 0.8364f
CD172 dout1_72  0 0.8364f
CD173 dout1_73  0 0.8364f
CD174 dout1_74  0 0.8364f
CD175 dout1_75  0 0.8364f
CD176 dout1_76  0 0.8364f
CD177 dout1_77  0 0.8364f
CD178 dout1_78  0 0.8364f
CD179 dout1_79  0 0.8364f
CD180 dout1_80  0 0.8364f
CD181 dout1_81  0 0.8364f
CD182 dout1_82  0 0.8364f
CD183 dout1_83  0 0.8364f
CD184 dout1_84  0 0.8364f
CD185 dout1_85  0 0.8364f
CD186 dout1_86  0 0.8364f
CD187 dout1_87  0 0.8364f
CD188 dout1_88  0 0.8364f
CD189 dout1_89  0 0.8364f
CD190 dout1_90  0 0.8364f
CD191 dout1_91  0 0.8364f
CD192 dout1_92  0 0.8364f
CD193 dout1_93  0 0.8364f
CD194 dout1_94  0 0.8364f
CD195 dout1_95  0 0.8364f
CD196 dout1_96  0 0.8364f
CD197 dout1_97  0 0.8364f
CD198 dout1_98  0 0.8364f
CD199 dout1_99  0 0.8364f
CD1100 dout1_100  0 0.8364f
CD1101 dout1_101  0 0.8364f
CD1102 dout1_102  0 0.8364f
CD1103 dout1_103  0 0.8364f
CD1104 dout1_104  0 0.8364f
CD1105 dout1_105  0 0.8364f
CD1106 dout1_106  0 0.8364f
CD1107 dout1_107  0 0.8364f
CD1108 dout1_108  0 0.8364f
CD1109 dout1_109  0 0.8364f
CD1110 dout1_110  0 0.8364f
CD1111 dout1_111  0 0.8364f
CD1112 dout1_112  0 0.8364f
CD1113 dout1_113  0 0.8364f
CD1114 dout1_114  0 0.8364f
CD1115 dout1_115  0 0.8364f
CD1116 dout1_116  0 0.8364f
CD1117 dout1_117  0 0.8364f
CD1118 dout1_118  0 0.8364f
CD1119 dout1_119  0 0.8364f

* Important signals for debug
* bl:	xfreepdk45_sram_1w1r_128x120_30.xbank0.bl_1_0
* br:	xfreepdk45_sram_1w1r_128x120_30.xbank0.br_1_0
* s_en:	xfreepdk45_sram_1w1r_128x120_30.s_en
* q:	xfreepdk45_sram_1w1r_128x120_30.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xfreepdk45_sram_1w1r_128x120_30.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 111000000100010010001000010101001101100100010000111101010101101111111000000010101100010110010001011000001100100010101111  to  address 0000000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 000110111110101010010010000100001111001001011001001110010011011101010001011111101100111100101010101111011001001111111111  to  address 1111110 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 111110000100100111100000110000011011101011011100101111011011001000011001010001001001010111001000000111110011111011001011  to  address 0000000 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 000110111110101010010010000100001111001001011001001110010011011101010001011111101100111100101010101111011001001111111111 from address 1111110 (from port 1) during cycle 4 (20ns - 25ns)
*	Reading 000110111110101010010010000100001111001001011001001110010011011101010001011111101100111100101010101111011001001111111111 from address 1111110 (from port 1) during cycle 5 (25ns - 30ns)
*	Reading 111110000100100111100000110000011011101011011100101111011011001000011001010001001001010111001000000111110011111011001011 from address 0000000 (from port 1) during cycle 6 (30ns - 35ns)
*	Writing (partial) 000010010010100111001001010000101100011101000010110001000110100000111111111100101010010100001001011010001001001000010100  to  address 1111110 with mask bit 1000 (from port 0) during cycle 8 (40ns - 45ns)
*	Writing (partial) 101001100011100111001110111001110010100001010000100110110011100111100100011000000100010001011111010001010010000011101011  to  address 0000000 with mask bit 0110 (from port 0) during cycle 9 (45ns - 50ns)
*	Writing (partial) 111010001011011100001111001101011101001100110100011111010111111000011001001000110111001110110000001010000101111110001000  to  address 1111110 with mask bit 1101 (from port 0) during cycle 10 (50ns - 55ns)
*	Writing (partial) 101001011101110010010001111010101111110100011001001001010011110100010101100000001010011001001100010001001001000101011100  to  address 1111110 with mask bit 0011 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 111110000100100111100000110000110010100001010000100110110011100111100100011000000100010001001000000111110011111011001011 from address 0000000 (from port 1) during cycle 14 (70ns - 75ns)
*	Writing 101001010011010110001111010000101100111110011100111000101000101011000100001011001100101001100101011011001110010010110011  to  address 0000000 (from port 0) during cycle 15 (75ns - 80ns)
*	Writing 110000011010000110101000110011010000101101011011100011011001110011011011001001101001000100111010000000100100001010001110  to  address 0000000 (from port 0) during cycle 16 (80ns - 85ns)
*	Writing (partial) 000001010101101101101011001111111101100101111001101001100010010101100010000000100101110000100101011101101100101010011000  to  address 0000000 with mask bit 1010 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 000001010101101101101011001111010000101101011011100011011001010101100010000000100101110000111010000000100100001010001110 from address 0000000 (from port 1) during cycle 18 (90ns - 95ns)
*	Writing 110110001101000011010101011001101111010101101011011001101010110100000111000010110100100111110100100001010011110110110010  to  address 0000000 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 111010001011011100001111001101011101001100110100011111010111110100010101100000001010011001001100010001001001000101011100 from address 1111110 (from port 1) during cycle 19 (95ns - 100ns)
*	Reading 110110001101000011010101011001101111010101101011011001101010110100000111000010110100100111110100100001010011110110110010 from address 0000000 (from port 1) during cycle 20 (100ns - 105ns)
*	Writing 011100001111011100010001110011100001011010011111110100111010010110011010101011000110011011100110011011110100000110101101  to  address 0000000 (from port 0) during cycle 21 (105ns - 110ns)
*	Writing (partial) 110000101001000111100111011101101110100001001011101010100010001111001101001001010100110011001111001011100011001101001101  to  address 1111110 with mask bit 1000 (from port 0) during cycle 22 (110ns - 115ns)
*	Writing 000011010001111010010010111011011011100111001101010101110101101011011111110010100100010010001010101101101011011001010110  to  address 0000000 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 000011010001111010010010111011011011100111001101010101110101101011011111110010100100010010001010101101101011011001010110 from address 0000000 (from port 1) during cycle 24 (120ns - 125ns)
*	Reading 110000101001000111100111011101011101001100110100011111010111110100010101100000001010011001001100010001001001000101011100 from address 1111110 (from port 1) during cycle 25 (125ns - 130ns)
*	Writing 011110111010100101111011111000011100000111011100010000001011101011000100111000100000111111111010101010110011001001000111  to  address 1111110 (from port 0) during cycle 26 (130ns - 135ns)
*	Writing 011001001101011111010101001111000111110010001000110010001001100011110000010010010111001101010100100000100110101001111110  to  address 1111110 (from port 0) during cycle 27 (135ns - 140ns)
*	Reading 000011010001111010010010111011011011100111001101010101110101101011011111110010100100010010001010101101101011011001010110 from address 0000000 (from port 1) during cycle 28 (140ns - 145ns)
*	Writing (partial) 111100101100101110101101001110000010110001011110000010100110000010101101111110110111101011101111111110001011110011100010  to  address 0000000 with mask bit 1100 (from port 0) during cycle 29 (145ns - 150ns)
*	Writing 011110000101100010011011111100011100001011111000100101111110000000010100111010000010111100111101001001100010011010000110  to  address 0000000 (from port 0) during cycle 33 (165ns - 170ns)
*	Writing 101111100101000110101000001100001111100010110100111010011010011100101000110011010010101111110101001101001000010110110111  to  address 0000000 (from port 0) during cycle 34 (170ns - 175ns)
*	Writing 101010111100110110001101100001100001000001001111001011000000000010101011111100110001001010100001001101011000011001111110  to  address 1111110 (from port 0) during cycle 35 (175ns - 180ns)
*	Writing 101011000001000011011101100010100100001100111001000000011101110110001010101101000111000001010001001111011101101110111010  to  address 0000000 (from port 0) during cycle 36 (180ns - 185ns)
*	Writing 010101100010100001011101011111100110001010111101001011000110001010100011100010001011111101010110100101111010000001011010  to  address 0000000 (from port 0) during cycle 37 (185ns - 190ns)
*	Writing 000101001101100100010010111101100001011010110010110010100100100101001001111011111110000001001101101110111100001100010011  to  address 0000000 (from port 0) during cycle 38 (190ns - 195ns)
*	Writing (partial) 010100100000000011000010111111010100001011011010001001100010001001001000001111011011011000111011000011010110111010001010  to  address 0000000 with mask bit 1010 (from port 0) during cycle 39 (195ns - 200ns)
*	Writing 011001010010011100110011110110100010001011011001000110101011111001010000001001010000010111110010011101101101110010100001  to  address 1111110 (from port 0) during cycle 41 (205ns - 210ns)
*	Writing (partial) 001100111010100100110010011111000011000111010111001110100111111000011111110111001000000000011011110000000010001101011110  to  address 0000000 with mask bit 0011 (from port 0) during cycle 42 (210ns - 215ns)
*	Reading 011001010010011100110011110110100010001011011001000110101011111001010000001001010000010111110010011101101101110010100001 from address 1111110 (from port 1) during cycle 42 (210ns - 215ns)
*	Writing (partial) 001100010011101001011110101011111111111110100101101001111100101111011000011000111001001101101111000110000111111101000000  to  address 0000000 with mask bit 1001 (from port 0) during cycle 43 (215ns - 220ns)
*	Reading 011001010010011100110011110110100010001011011001000110101011111001010000001001010000010111110010011101101101110010100001 from address 1111110 (from port 1) during cycle 45 (225ns - 230ns)
*	Writing (partial) 101000101001000111010011111000010100100011111110001000100011110101100011101010101000001110110001010110110011100110101100  to  address 1111110 with mask bit 1010 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 001100010011101001011110101011100001011010110010110010100100111000011111110111001000000000101111000110000111111101000000 from address 0000000 (from port 1) during cycle 46 (230ns - 235ns)
*	Reading 101000101001000111010011111000100010001011011001000110101011110101100011101010101000001110110010011101101101110010100001 from address 1111110 (from port 1) during cycle 47 (235ns - 240ns)
*	Writing 011100101000111000111010110001100000011111001100100100001001101111110110000111010100000011001100110110010010101111110000  to  address 1111110 (from port 0) during cycle 48 (240ns - 245ns)
*	Writing 100011000010010011101101100110111011111110011011100110011100001011001010000100011100110101110111100101000111101000001100  to  address 0000000 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 011100101000111000111010110001100000011111001100100100001001101111110110000111010100000011001100110110010010101111110000 from address 1111110 (from port 1) during cycle 49 (245ns - 250ns)
*	Writing 000100101000001010010001010100111100010010100110000110000011110010000101101110110000010000000011000101010100100001001101  to  address 1111110 (from port 0) during cycle 50 (250ns - 255ns)
*	Reading 100011000010010011101101100110111011111110011011100110011100001011001010000100011100110101110111100101000111101000001100 from address 0000000 (from port 1) during cycle 50 (250ns - 255ns)
*	Reading 000100101000001010010001010100111100010010100110000110000011110010000101101110110000010000000011000101010100100001001101 from address 1111110 (from port 1) during cycle 51 (255ns - 260ns)
*	Writing (partial) 100101011010000001101011010010011100111000100110110110101100110001000001010110111011100110110100110101110000110111101100  to  address 0000000 with mask bit 1100 (from port 0) during cycle 52 (260ns - 265ns)
*	Writing 010111101110011111001010011000000110101010000011010011110100011100011101001100101110111001011110000001010000101101100000  to  address 0000000 (from port 0) during cycle 53 (265ns - 270ns)
*	Reading 000100101000001010010001010100111100010010100110000110000011110010000101101110110000010000000011000101010100100001001101 from address 1111110 (from port 1) during cycle 53 (265ns - 270ns)
*	Writing (partial) 100101110100100000001100001000100001100100011101110000010100111111111110000001100011101110010011110000111111110100010000  to  address 0000000 with mask bit 1011 (from port 0) during cycle 54 (270ns - 275ns)
*	Writing (partial) 001111111000001111010010011010101010110000010011101000110011001010110101010111001001100111110011011111110100010011011010  to  address 0000000 with mask bit 0010 (from port 0) during cycle 55 (275ns - 280ns)
*	Writing 101000011110010100010111111011101011101010110010000110001101010000011110110101101100101011110011000111011010101000010100  to  address 1111110 (from port 0) during cycle 56 (280ns - 285ns)
*	Writing (partial) 001010100000000001001000001111010000011100110100010011110111101011100001111110011000011100010011011101101101100000110111  to  address 1111110 with mask bit 1010 (from port 0) during cycle 57 (285ns - 290ns)
*	Writing 000011101111001001110100001001100011001101001100100000100101110011011100110110111001110010111000011001111100100110111111  to  address 0000000 (from port 0) during cycle 58 (290ns - 295ns)
*	Writing 000101001111000000001101110111100100010110011010110111010100000101101101000001010010011011001001000100111100111000001001  to  address 1111110 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing 011100001111111001101110100111101001001000111110110011010010000001100001101010011001100100001011101100101111001101110110  to  address 1111110 (from port 0) during cycle 60 (300ns - 305ns)
*	Writing 001111001001100001100111101110011001010101001100111110110000100011111011100011010101100101011011101100100100111011001000  to  address 1111110 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 001111001001100001100111101110011001010101001100111110110000100011111011100011010101100101011011101100100100111011001000 from address 1111110 (from port 1) during cycle 62 (310ns - 315ns)
*	Writing 110100111110110010011000011011001111110000010101000100100100110010111111011011111010010100011101011100001001101110010000  to  address 0000000 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing 111100011111110110000001001000000101111111000000101010100001110100011011010101000101001100110000101110001110010110100100  to  address 1111110 (from port 0) during cycle 64 (320ns - 325ns)
*	Reading 110100111110110010011000011011001111110000010101000100100100110010111111011011111010010100011101011100001001101110010000 from address 0000000 (from port 1) during cycle 65 (325ns - 330ns)
*	Writing (partial) 101100001001100100010011100101101001001101011111101011011101101101001010000011100011000100110001110101100101001110101011  to  address 0000000 with mask bit 0111 (from port 0) during cycle 66 (330ns - 335ns)
*	Reading 111100011111110110000001001000000101111111000000101010100001110100011011010101000101001100110000101110001110010110100100 from address 1111110 (from port 1) during cycle 66 (330ns - 335ns)
*	Writing (partial) 011010110010011000101111100101110001101001001100101001101001100011101010001011001000000111001111110101011010000010000001  to  address 1111110 with mask bit 0011 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 100110100000011110110110100101011000101011010110100100011111110110001111100011101100100011101111111000010001001101100100  to  address 0000000 (from port 0) during cycle 69 (345ns - 350ns)
*	Reading 111100011111110110000001001000000101111111000000101010100001100011101010001011001000000111001111110101011010000010000001 from address 1111110 (from port 1) during cycle 69 (345ns - 350ns)
*	Writing 001001110101000011011111011000000001000100011011001111011100000110001000010001111000001101001001110011001010101011111010  to  address 0000000 (from port 0) during cycle 70 (350ns - 355ns)
*	Reading 111100011111110110000001001000000101111111000000101010100001100011101010001011001000000111001111110101011010000010000001 from address 1111110 (from port 1) during cycle 70 (350ns - 355ns)
*	Writing (partial) 000100010100110010000101100111001101111110001100010110000111011011110011011000001110000100101101111110011100110111000010  to  address 0000000 with mask bit 1000 (from port 0) during cycle 72 (360ns - 365ns)
*	Writing 110010101100101101101011001101101000111000001001110110000010110001010100110110101100011010010100001111110011110011001110  to  address 0000000 (from port 0) during cycle 74 (370ns - 375ns)
*	Writing (partial) 110000111100101101000010100000010110111001101100001001100110100001101001111111011111101110111110100110000011101010000111  to  address 1111110 with mask bit 0011 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 111100011111110110000001001000000101111111000000101010100001100001101001111111011111101110111110100110000011101010000111 from address 1111110 (from port 1) during cycle 76 (380ns - 385ns)
*	Writing 011101101010111100011101110010011000011110100100010011111000011100111011001110010100101101111100101010111010101111011011  to  address 1111110 (from port 0) during cycle 77 (385ns - 390ns)
*	Writing 111000110100001000101111110000010111101010100111001000111100101011101110000111101011010010111110110100111000001111100111  to  address 0000000 (from port 0) during cycle 78 (390ns - 395ns)
*	Writing (partial) 000001101000101001000100100010011000000011101111010101000011111001100101111111010011000101101110010100101110010010111010  to  address 1111110 with mask bit 0100 (from port 0) during cycle 79 (395ns - 400ns)
*	Writing (partial) 001101101001010001010000111000101001010100011111001110100100111001110010000110101101110010010110101101000000110001001001  to  address 1111110 with mask bit 1000 (from port 0) during cycle 80 (400ns - 405ns)
*	Writing 100111000100110101011111000110101001000011010110101110000011101110010000111101011100001000101011110101001010010000110101  to  address 0000000 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing (partial) 000111110000111000011110010111111100100010001110100001011011010111011110101101011100010111000000010000010010001001110110  to  address 0000000 with mask bit 1011 (from port 0) during cycle 82 (410ns - 415ns)
*	Writing (partial) 111100011101111101001010010010111111011001100110000000010001010100001111010101011010011011110111101101101101001101001101  to  address 1111110 with mask bit 0011 (from port 0) during cycle 83 (415ns - 420ns)
*	Writing (partial) 110111011101101111001011100001010001000100011010010111111110100101111101011110010110000100011100000111000010101111111101  to  address 1111110 with mask bit 0010 (from port 0) during cycle 84 (420ns - 425ns)
*	Writing 000011000010111111011001001011100100111001101110110101111001001111110010101111111001101000000010111111101010001010001101  to  address 0000000 (from port 0) during cycle 85 (425ns - 430ns)
*	Writing (partial) 001001110111000110010101101110000011010001000111101011100100101100101100001000100100001010010110011111010011110000111011  to  address 1111110 with mask bit 0111 (from port 0) during cycle 86 (430ns - 435ns)
*	Reading 000011000010111111011001001011100100111001101110110101111001001111110010101111111001101000000010111111101010001010001101 from address 0000000 (from port 1) during cycle 86 (430ns - 435ns)
*	Writing (partial) 111100100111010101010101100101000000100111101001111111110101011000111000111101110101011110010100100000010011011110000011  to  address 0000000 with mask bit 0001 (from port 0) during cycle 87 (435ns - 440ns)
*	Writing 010010111010110110101011100000010001101011000111101001010001011101010010000110000100001000000101110001000110101000011101  to  address 0000000 (from port 0) during cycle 88 (440ns - 445ns)
*	Reading 001101101001010001010000111000000011010001000111101011100100101100101100001000100100001010010110011111010011110000111011 from address 1111110 (from port 1) during cycle 88 (440ns - 445ns)
*	Writing (partial) 110111010000011111000101100101111000001111111001001101110111110101001111001110111000110101010110110111110000001011010011  to  address 1111110 with mask bit 0101 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 001101101001010001010000111000111000001111111001001101110111101100101100001000100100001010010110110111110000001011010011 from address 1111110 (from port 1) during cycle 90 (450ns - 455ns)
*	Writing 001010010001001010011000001101111001011111011000110011111110111101011110010011101011000100010101110111110011000101001011  to  address 0000000 (from port 0) during cycle 92 (460ns - 465ns)
*	Writing 100111100000011000100000000010100010110010100000010001010001100010110100100100011100110001101110110010110100110111001101  to  address 0000000 (from port 0) during cycle 94 (470ns - 475ns)
*	Writing (partial) 100011100111010011100101100100101011100111110001011111000101100110000010010100001001111100101101011010111011110001111111  to  address 1111110 with mask bit 0001 (from port 0) during cycle 96 (480ns - 485ns)
*	Writing 110001100001101101111111010110111010010011101101011001111111110101111100100010100010010111100100011001111001011111110111  to  address 0000000 (from port 0) during cycle 97 (485ns - 490ns)
*	Writing (partial) 110001100100010100011010011100100110101101001010010100100100011000011100001101111011001001010001001100011000111010000101  to  address 1111110 with mask bit 0010 (from port 0) during cycle 98 (490ns - 495ns)
*	Writing 001000101010111100100110110111111111010001010100000101100100101101111010000000110011010111000110100111101010000111111100  to  address 1111110 (from port 0) during cycle 99 (495ns - 500ns)
*	Writing (partial) 001010111010000001101000111011001110000001101001110111111010011110011011111110011010100000110010100000100100101000011000  to  address 1111110 with mask bit 1101 (from port 0) during cycle 100 (500ns - 505ns)
*	Writing 101001011010010000011011001001000000111010001010110100010110010111010101111111110111011010000110011111001011100001000010  to  address 0000000 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 001010111010000001101000111011001110000001101001110111111010101101111010000000110011010111110010100000100100101000011000 from address 1111110 (from port 1) during cycle 101 (505ns - 510ns)
*	Reading 001010111010000001101000111011001110000001101001110111111010101101111010000000110011010111110010100000100100101000011000 from address 1111110 (from port 1) during cycle 102 (510ns - 515ns)
*	Reading 001010111010000001101000111011001110000001101001110111111010101101111010000000110011010111110010100000100100101000011000 from address 1111110 (from port 1) during cycle 103 (515ns - 520ns)
*	Reading 101001011010010000011011001001000000111010001010110100010110010111010101111111110111011010000110011111001011100001000010 from address 0000000 (from port 1) during cycle 104 (520ns - 525ns)
*	Reading 001010111010000001101000111011001110000001101001110111111010101101111010000000110011010111110010100000100100101000011000 from address 1111110 (from port 1) during cycle 105 (525ns - 530ns)
*	Reading 101001011010010000011011001001000000111010001010110100010110010111010101111111110111011010000110011111001011100001000010 from address 0000000 (from port 1) during cycle 106 (530ns - 535ns)
*	Writing (partial) 001000001110110001111110010100010001001000010110100100010100110000001101000011011111010010010100111011101001001010111011  to  address 1111110 with mask bit 0010 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 101001011010010000011011001001000000111010001010110100010110010111010101111111110111011010000110011111001011100001000010 from address 0000000 (from port 1) during cycle 107 (535ns - 540ns)
*	Reading 001010111010000001101000111011001110000001101001110111111010110000001101000011011111010010110010100000100100101000011000 from address 1111110 (from port 1) during cycle 108 (540ns - 545ns)
*	Reading 101001011010010000011011001001000000111010001010110100010110010111010101111111110111011010000110011111001011100001000010 from address 0000000 (from port 1) during cycle 109 (545ns - 550ns)
*	Writing 101001111011100101000011010100110110001111111011110100010010111000111110110100011100001100000101110110110100001100100010  to  address 0000000 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 001010111010000001101000111011001110000001101001110111111010110000001101000011011111010010110010100000100100101000011000 from address 1111110 (from port 1) during cycle 110 (550ns - 555ns)
*	Writing (partial) 110011001010011000110011010000011010100000000100001001000001011010101101110000001111110110100000010111010010001100000000  to  address 1111110 with mask bit 1100 (from port 0) during cycle 111 (555ns - 560ns)
*	Writing (partial) 001010110100010010000001110000100111101010000000111111111110010011111101010010000001110100001111110101100000010000101100  to  address 1111110 with mask bit 1010 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 101001111011100101000011010100110110001111111011110100010010111000111110110100011100001100000101110110110100001100100010 from address 0000000 (from port 1) during cycle 113 (565ns - 570ns)
*	Writing (partial) 000000101101111100010001111001101011001100011101011001111100101100100100110011111100000111001101011010001001110111011011  to  address 1111110 with mask bit 0111 (from port 0) during cycle 114 (570ns - 575ns)
*	Reading 101001111011100101000011010100110110001111111011110100010010111000111110110100011100001100000101110110110100001100100010 from address 0000000 (from port 1) during cycle 114 (570ns - 575ns)
*	Writing (partial) 001010111101110111111001101100110111011000100111110110000110111100111000101001010001111000001000101110111000011100100110  to  address 1111110 with mask bit 1000 (from port 0) during cycle 115 (575ns - 580ns)
*	Reading 101001111011100101000011010100110110001111111011110100010010111000111110110100011100001100000101110110110100001100100010 from address 0000000 (from port 1) during cycle 116 (580ns - 585ns)
*	Writing 101011111000001010111001010100001111011110011010101011011111001000001011111100100011110110001011110110110101101010010001  to  address 1111110 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 101001111011100101000011010100110110001111111011110100010010111000111110110100011100001100000101110110110100001100100010 from address 0000000 (from port 1) during cycle 118 (590ns - 595ns)
*	Reading 101011111000001010111001010100001111011110011010101011011111001000001011111100100011110110001011110110110101101010010001 from address 1111110 (from port 1) during cycle 119 (595ns - 600ns)
*	Writing 000001000000000110001000001110110001011101100110010001010001100001011011111101000100010111111101101010000010011110000000  to  address 0000000 (from port 0) during cycle 121 (605ns - 610ns)
*	Writing 100111101010000011000001011111111011010101111001100101001111110000110110100110011011010110101110111111101110111011010000  to  address 0000000 (from port 0) during cycle 122 (610ns - 615ns)
*	Writing (partial) 011101011101111101111010011010100000011010011110001111100110100100010100000110000011001001100010001001001001010000000001  to  address 0000000 with mask bit 0001 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing (partial) 001101110101110001111010111111100001011010101010001110110110100101101010101101110101100101111000100110100001001101011100  to  address 1111110 with mask bit 0101 (from port 0) during cycle 125 (625ns - 630ns)
*	Writing 110000101011100100000000110011011111111010011110000001000101010110001001011000100011111000100000101110100011101111111100  to  address 0000000 (from port 0) during cycle 127 (635ns - 640ns)
*	Writing (partial) 011110100010001010110010000110101000010101000100100101000011111011110101110111111001010111000010000100110111000111100100  to  address 1111110 with mask bit 1100 (from port 0) during cycle 128 (640ns - 645ns)
*	Writing 100011000110111111000011101110111110011111101101011111001010111010000101111010010010110101000010010101011000001111000001  to  address 0000000 (from port 0) during cycle 129 (645ns - 650ns)
*	Reading 011110100010001010110010000110101000010101000100100101000011001000001011111100100011110110111000100110100001001101011100 from address 1111110 (from port 1) during cycle 130 (650ns - 655ns)
*	Writing 100110010111000000000101100110101111110100001110001011110011010111110011010101101000110000000101101100001100000100101110  to  address 1111110 (from port 0) during cycle 131 (655ns - 660ns)
*	Writing (partial) 000001100110111000001101110011001001111101000100000000010110000011000001111011110110000001011110010110011000101101101011  to  address 0000000 with mask bit 1110 (from port 0) during cycle 132 (660ns - 665ns)
*	Reading 100110010111000000000101100110101111110100001110001011110011010111110011010101101000110000000101101100001100000100101110 from address 1111110 (from port 1) during cycle 132 (660ns - 665ns)
*	Writing 111111000101100101111010001011111001110000011001101111000010101001111101111110001001000001011111010001001111110101111001  to  address 1111110 (from port 0) during cycle 134 (670ns - 675ns)
*	Reading 000001100110111000001101110011001001111101000100000000010110000011000001111011110110000001000010010101011000001111000001 from address 0000000 (from port 1) during cycle 134 (670ns - 675ns)
*	Writing 001100011011101001011111010100010101101100100100010011000011110110010001011100001110001111101110011111111111000000101101  to  address 1111110 (from port 0) during cycle 135 (675ns - 680ns)
*	Reading 000001100110111000001101110011001001111101000100000000010110000011000001111011110110000001000010010101011000001111000001 from address 0000000 (from port 1) during cycle 135 (675ns - 680ns)
*	Writing 100100110111000010100100100101101010101100010011101100000100111010000000111001000100100101001111011000100001001100110011  to  address 1111110 (from port 0) during cycle 136 (680ns - 685ns)
*	Writing (partial) 100101110010100100101010000101100110010011101111111111010111100010000111000100111111101001101110110011010111000101101111  to  address 0000000 with mask bit 0110 (from port 0) during cycle 137 (685ns - 690ns)
*	Writing 101011101011010010000011011111101010011101001111111101010111001111101101001011000110001110011100110001011100000111011011  to  address 0000000 (from port 0) during cycle 138 (690ns - 695ns)
*	Writing 100011011011001101010111001011001101110111001011000000011110001000110101100111110000101101111011111011101000011010100000  to  address 0000000 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing (partial) 101111101111110101101011100011100101101100000100101011000100011100111000101110010001001110011111011100010101000101100101  to  address 1111110 with mask bit 1100 (from port 0) during cycle 141 (705ns - 710ns)
*	Writing (partial) 110000001000001001111101011100100001101000100101100011001010100001011010001101010011001111110001000101000101111000010100  to  address 1111110 with mask bit 1000 (from port 0) during cycle 142 (710ns - 715ns)
*	Writing 010111100101001000110110001010101100000010111011001111100001111011011111000101001010110000110110111111101011101110100010  to  address 1111110 (from port 0) during cycle 144 (720ns - 725ns)
*	Writing 111011111011010001110010010110001110100000010100001000111001111001111000010011100010110110010110010101011001101110011100  to  address 0000000 (from port 0) during cycle 145 (725ns - 730ns)
*	Reading 010111100101001000110110001010101100000010111011001111100001111011011111000101001010110000110110111111101011101110100010 from address 1111110 (from port 1) during cycle 147 (735ns - 740ns)
*	Writing (partial) 101001000100100011100110111001100011111010100000010010000000110100100001101110011100111010100011101001011110110100110100  to  address 1111110 with mask bit 1000 (from port 0) during cycle 148 (740ns - 745ns)
*	Writing (partial) 111001110101001010100010010111011010111010001001011101111101110111010010101010101111011000000111010101000010100000100011  to  address 0000000 with mask bit 1110 (from port 0) during cycle 149 (745ns - 750ns)
*	Writing 000111111011001111011100111010010001010111000100110110000011111100111010101111000101001100000001000101101000111010011001  to  address 1111110 (from port 0) during cycle 150 (750ns - 755ns)
*	Writing (partial) 011001010010101000001100000111101000110101110101111001101010000011110001100011110100100100010011010101011001100100110110  to  address 0000000 with mask bit 0011 (from port 0) during cycle 151 (755ns - 760ns)
*	Writing 110001010001011011000110110000110111010000100000001100000001001001011101011000100001101010110000100111010000111110100011  to  address 1111110 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 110001010001011011000110110000110111010000100000001100000001001001011101011000100001101010110000100111010000111110100011 from address 1111110 (from port 1) during cycle 153 (765ns - 770ns)
*	Writing 001100011001011100100110011001101110000010001001011110111101001101010011101110000010100000010001110010011100011100000101  to  address 0000000 (from port 0) during cycle 154 (770ns - 775ns)
*	Writing (partial) 111001001001100100000110110111001100100001111101010011011111001101100001110101111011000010010000100010011100000000011110  to  address 0000000 with mask bit 0100 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 110001010001011011000110110000110111010000100000001100000001001001011101011000100001101010110000100111010000111110100011 from address 1111110 (from port 1) during cycle 156 (780ns - 785ns)
*	Writing (partial) 110100011000110010110101111100011001001011110001100001101101100100110000110000100010010001010100001000111010101110011100  to  address 1111110 with mask bit 0100 (from port 0) during cycle 157 (785ns - 790ns)
*	Writing (partial) 110111100000111101011010110001000100111011110111010101101011101101001110111010011100011101111011110000011100111011101101  to  address 0000000 with mask bit 0101 (from port 0) during cycle 158 (790ns - 795ns)
*	Reading 001100011001011100100110011001000100111011110111010101101011001101010011101110000010100000111011110000011100111011101101 from address 0000000 (from port 1) during cycle 159 (795ns - 800ns)
*	Writing 110100001010000100101011001110100101100001100100100011001111001100001011111100110110100101001100001100100011101100010101  to  address 0000000 (from port 0) during cycle 160 (800ns - 805ns)
*	Writing 110010101110110001101001111101110101000110011111110100101011100110101000101111001001110001001100101111010110110010000101  to  address 1111110 (from port 0) during cycle 161 (805ns - 810ns)
*	Reading 110100001010000100101011001110100101100001100100100011001111001100001011111100110110100101001100001100100011101100010101 from address 0000000 (from port 1) during cycle 161 (805ns - 810ns)
*	Writing 000001011111111101111001101110000001010111010010111110000100111101110001010100001000101111000000000110100001011011100111  to  address 0000000 (from port 0) during cycle 162 (810ns - 815ns)
*	Writing (partial) 111110010100100100110001110010101010101110001100101110000110101000011110011011101010100001101011000101111010000110111010  to  address 0000000 with mask bit 1001 (from port 0) during cycle 164 (820ns - 825ns)
*	Writing (partial) 111101000110101111101000111101000110101011110111110111001000010101111001011111011101110000001101101010110000111101101111  to  address 0000000 with mask bit 0110 (from port 0) during cycle 165 (825ns - 830ns)
*	Writing (partial) 001010100101000111100010100111110111011100110000001000111010100111111001110111110010000000100100010010011101011001100011  to  address 1111110 with mask bit 0001 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 111110010100100100110001110010000110101011110111110111001000010101111001011111011101110000101011000101111010000110111010 from address 0000000 (from port 1) during cycle 166 (830ns - 835ns)
*	Writing 110011010110100111100100101110000111101000011000010101101101001101010011110100101000101000011001110110101011111100101110  to  address 0000000 (from port 0) during cycle 167 (835ns - 840ns)
*	Writing 110001111101010010111010101111101011000101011010010101010000010011001011100011110000010011010001110110111010001010001110  to  address 1111110 (from port 0) during cycle 168 (840ns - 845ns)
*	Writing (partial) 010111010100100001110111101001110111010110111100000100101001010010110010001010001110100010010101010101110001111011111101  to  address 1111110 with mask bit 0110 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 110011010110100111100100101110000111101000011000010101101101001101010011110100101000101000011001110110101011111100101110 from address 0000000 (from port 1) during cycle 170 (850ns - 855ns)
*	Writing (partial) 001100011100001011000100101100011011101111000110100001100000000000110001000000001000101011001010101010101001011000010111  to  address 1111110 with mask bit 0110 (from port 0) during cycle 171 (855ns - 860ns)
*	Reading 110011010110100111100100101110000111101000011000010101101101001101010011110100101000101000011001110110101011111100101110 from address 0000000 (from port 1) during cycle 171 (855ns - 860ns)
*	Writing 011000010001010110001111001001001000101010111011110011011011111100110000000010111000000101011111001001101010010010000010  to  address 0000000 (from port 0) during cycle 172 (860ns - 865ns)
*	Reading 110001111101010010111010101111011011101111000110100001100000000000110001000000001000101011010001110110111010001010001110 from address 1111110 (from port 1) during cycle 173 (865ns - 870ns)
*	Reading 011000010001010110001111001001001000101010111011110011011011111100110000000010111000000101011111001001101010010010000010 from address 0000000 (from port 1) during cycle 174 (870ns - 875ns)
*	Reading 110001111101010010111010101111011011101111000110100001100000000000110001000000001000101011010001110110111010001010001110 from address 1111110 (from port 1) during cycle 175 (875ns - 880ns)
*	Writing (partial) 110100000011111110000001111101001100001111100111111100011111000011000100010001010000110000110100000111010000001001111110  to  address 0000000 with mask bit 1101 (from port 0) during cycle 176 (880ns - 885ns)
*	Writing 111101000001101011100010000011111000110000101110001101001111110000001011001011100100000110010010110101011000100001111110  to  address 1111110 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing (partial) 110100010110111101100110001101011000111100000111100111101100001000001010110010011101010000011010110110011100000110000000  to  address 1111110 with mask bit 0100 (from port 0) during cycle 180 (900ns - 905ns)
*	Writing (partial) 000101101110100111111100011010111000111010101100101110100101110000010010011110000110011111101110111110011010110000000110  to  address 1111110 with mask bit 0001 (from port 0) during cycle 181 (905ns - 910ns)
*	Writing (partial) 100101010011010100000001001011111001110010011001100101001111101100011000110001000001101001111100101100001011000000001100  to  address 0000000 with mask bit 0101 (from port 0) during cycle 183 (915ns - 920ns)
*	Writing (partial) 101101011101000111101101010100001010000101101100100110101000000001100000010001010100100001110011011011010101000101010100  to  address 1111110 with mask bit 1010 (from port 0) during cycle 184 (920ns - 925ns)
*	Writing (partial) 110010011000001100101001010000101111011001000000101110110101111011011111010011101010000101111110011110111001100110010011  to  address 1111110 with mask bit 1101 (from port 0) during cycle 185 (925ns - 930ns)
*	Writing 000101100010110110100001100000000000110010101001100101100011011001100010101110000001100100000111011101001100110111101110  to  address 0000000 (from port 0) during cycle 187 (935ns - 940ns)
*	Writing (partial) 111001101110000111011110001011000100010001010100100000001011010110001110010010010001000111100011010101110011000100111011  to  address 1111110 with mask bit 0110 (from port 0) during cycle 188 (940ns - 945ns)
*	Writing (partial) 100101111011100001001100011001011100100000100011011011000010110101100111011001111100111111111000110111111111111110110000  to  address 1111110 with mask bit 1000 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing 100110110011100110101101100101111110100000011010101000011100100101011100101001001101011011110010101000100110100001010010  to  address 1111110 (from port 0) during cycle 191 (955ns - 960ns)
*	Writing 000011011010110000000001000101111001101101101101010010001100101101111000110000111011111001000101101011000111011011100100  to  address 1111110 (from port 0) during cycle 192 (960ns - 965ns)
*	Writing (partial) 100111010000000000101000000100101100000101011011110111110101110010000001101001110001100100000000011110000101101100010011  to  address 1111110 with mask bit 0001 (from port 0) during cycle 193 (965ns - 970ns)
*	Reading 000101100010110110100001100000000000110010101001100101100011011001100010101110000001100100000111011101001100110111101110 from address 0000000 (from port 1) during cycle 194 (970ns - 975ns)
*	Reading 000101100010110110100001100000000000110010101001100101100011011001100010101110000001100100000111011101001100110111101110 from address 0000000 (from port 1) during cycle 196 (980ns - 985ns)
*	Writing 011111010100001001101110000001010101011000101110011111101011001110100100001001001011110100101111111000110100101001000011  to  address 0000000 (from port 0) during cycle 197 (985ns - 990ns)
*	Writing (partial) 111110111100111011101011110011100000010000000001111101111000010001010010100110111101000000110001111011010000001001010111  to  address 1111110 with mask bit 0011 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 011111010100001001101110000001010101011000101110011111101011001110100100001001001011110100101111111000110100101001000011 from address 0000000 (from port 1) during cycle 198 (990ns - 995ns)
*	Writing (partial) 010001000101001011111000110111011110001000110010010100010101011011001111101101110000000101010001010010001101110101001011  to  address 1111110 with mask bit 1100 (from port 0) during cycle 199 (995ns - 1000ns)
*	Reading 011111010100001001101110000001010101011000101110011111101011001110100100001001001011110100101111111000110100101001000011 from address 0000000 (from port 1) during cycle 199 (995ns - 1000ns)
*	Writing 100100000000001100110111111101111110100111101011111010010101110111010011110110111101011000100000000101101010101110010000  to  address 0000000 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 010001000101001011111000110111011110001000110010010100010101010001010010100110111101000000110001111011010000001001010111 from address 1111110 (from port 1) during cycle 200 (1000ns - 1005ns)
*	Reading 100100000000001100110111111101111110100111101011111010010101110111010011110110111101011000100000000101101010101110010000 from address 0000000 (from port 1) during cycle 201 (1005ns - 1010ns)
*	Reading 010001000101001011111000110111011110001000110010010100010101010001010010100110111101000000110001111011010000001001010111 from address 1111110 (from port 1) during cycle 202 (1010ns - 1015ns)
*	Writing (partial) 110010101101111000010001001010000110110100111011111011111001111000001110011100011000110010101000001011101011000101011100  to  address 1111110 with mask bit 0110 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 100100000000001100110111111101111110100111101011111010010101110111010011110110111101011000100000000101101010101110010000 from address 0000000 (from port 1) during cycle 203 (1015ns - 1020ns)
*	Writing (partial) 001001001010000011001001110100000100101001110011100011110010100001101011000110111010111010100000011000011000011110010110  to  address 1111110 with mask bit 1000 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_33  din0_33  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_34  din0_34  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_35  din0_35  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_36  din0_36  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_37  din0_37  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_38  din0_38  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_39  din0_39  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_40  din0_40  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_41  din0_41  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_42  din0_42  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_43  din0_43  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_44  din0_44  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_45  din0_45  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_46  din0_46  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_47  din0_47  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_48  din0_48  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_49  din0_49  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_50  din0_50  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_51  din0_51  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_52  din0_52  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_53  din0_53  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_54  din0_54  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_55  din0_55  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_56  din0_56  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_57  din0_57  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_58  din0_58  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_59  din0_59  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_60  din0_60  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_61  din0_61  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_62  din0_62  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_63  din0_63  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_64  din0_64  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_65  din0_65  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_66  din0_66  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_67  din0_67  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_68  din0_68  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_69  din0_69  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_70  din0_70  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_71  din0_71  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_72  din0_72  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_73  din0_73  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_74  din0_74  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_75  din0_75  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_76  din0_76  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_77  din0_77  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 0), (405, 1), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_78  din0_78  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_79  din0_79  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_80  din0_80  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_81  din0_81  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 0), (285, 1), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_82  din0_82  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_83  din0_83  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 1), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_84  din0_84  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_85  din0_85  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_86  din0_86  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_87  din0_87  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_88  din0_88  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_89  din0_89  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_90  din0_90  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_91  din0_91  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_92  din0_92  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_93  din0_93  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_94  din0_94  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_95  din0_95  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_96  din0_96  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_97  din0_97  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_98  din0_98  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 0), (280, 0), (285, 1), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_99  din0_99  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_100  din0_100  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_101  din0_101  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_102  din0_102  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_103  din0_103  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 1), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_104  din0_104  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.9v 609.745n 0.9v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 0), (275, 1), (280, 0), (285, 0), (290, 1), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 1), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 0), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_105  din0_105  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_106  din0_106  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 0), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_107  din0_107  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 0), (180, 1), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 1), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_108  din0_108  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_109  din0_109  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_110  din0_110  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 1), (195, 0), (200, 0), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 1), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_111  din0_111  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_112  din0_112  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 0), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 1), (435, 1), (440, 1), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_113  din0_113  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 0), (790, 1), (795, 1), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_114  din0_114  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.0v 959.745n 0.0v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 1), (280, 0), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 1), (825, 0), (830, 1), (835, 1), (840, 0), (845, 1), (850, 1), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_115  din0_115  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 1), (795, 1), (800, 1), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_116  din0_116  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 0), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 0), (410, 0), (415, 1), (420, 0), (425, 0), (430, 1), (435, 1), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 0), (765, 0), (770, 1), (775, 1), (780, 1), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Vdin0_117  din0_117  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_118  din0_118  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.9v 189.745n 0.9v 189.755n 0.0v 194.745n 0.0v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.9v 304.745n 0.9v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 0), (280, 1), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 1), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Vdin0_119  din0_119  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.0v 14.745n 0.0v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.0v 964.745n 0.0v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 0), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 0), (320, 1), (325, 1), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 1), (425, 0), (430, 1), (435, 0), (440, 0), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 1), (755, 0), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.9v 14.745n 0.9v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.9v 114.745n 0.9v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.9v 179.745n 0.9v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.0v 294.745n 0.0v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.0v 394.745n 0.0v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.0v 429.745n 0.0v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.9v 484.745n 0.9v 484.755n 0.0v 489.745n 0.0v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.9v 644.745n 0.9v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.9v 809.745n 0.9v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.0v 839.745n 0.0v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.9v 994.745n 0.9v 994.755n 0.9v 999.745n 0.9v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va1_0  a1_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_1  a1_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_2  a1_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_3  a1_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_4  a1_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_5  a1_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 0), (535, 0), (540, 1), (545, 0), (550, 1), (555, 1), (560, 1), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va1_6  a1_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.0v 524.745n 0.0v 524.755n 0.9v 529.745n 0.9v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.0v 874.745n 0.0v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 0), (100, 1), (105, 0), (110, 0), (115, 0), (120, 1), (125, 1), (130, 0), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 0), (320, 0), (325, 1), (330, 0), (335, 0), (340, 1), (345, 0), (350, 0), (355, 1), (360, 0), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 0), (465, 1), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 1), (570, 0), (575, 0), (580, 1), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 1), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 1), (720, 0), (725, 0), (730, 1), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 0), (775, 0), (780, 1), (785, 0), (790, 0), (795, 1), (800, 0), (805, 0), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 1), (890, 0), (895, 1), (900, 0), (905, 0), (910, 1), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.9v 94.745n 0.9v 94.755n 0.0v 99.745n 0.0v 99.755n 0.9v 104.745n 0.9v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.9v 204.745n 0.9v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.9v 239.745n 0.9v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.9v 314.745n 0.9v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.9v 369.745n 0.9v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.9v 384.745n 0.9v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.0v 464.745n 0.0v 464.755n 0.9v 469.745n 0.9v 469.755n 0.0v 474.745n 0.0v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.9v 624.745n 0.9v 624.755n 0.0v 629.745n 0.0v 629.755n 0.9v 634.745n 0.9v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.9v 654.745n 0.9v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.9v 719.745n 0.9v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.9v 769.745n 0.9v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.9v 784.745n 0.9v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.9v 799.745n 0.9v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.9v 854.745n 0.9v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.9v 889.745n 0.9v 889.755n 0.0v 894.745n 0.0v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.9v 914.745n 0.9v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.9v 934.745n 0.9v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.9v )
* (time, data): [(0, 1), (5, 1), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 0), (125, 0), (130, 1), (135, 1), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 0), (350, 0), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 0), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 1), (560, 1), (565, 0), (570, 0), (575, 1), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 1), (775, 1), (780, 0), (785, 1), (790, 1), (795, 0), (800, 1), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 0), (975, 1), (980, 0), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
VCSB1 CSB1 0 PWL (0n 0.9v 4.745n 0.9v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.0v 144.745n 0.0v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.9v 264.745n 0.9v 264.755n 0.0v 269.745n 0.0v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.0v 314.745n 0.0v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.9v 439.745n 0.9v 439.755n 0.0v 444.745n 0.0v 444.755n 0.9v 449.745n 0.9v 449.755n 0.0v 454.745n 0.0v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.0v 584.745n 0.0v 584.755n 0.9v 589.745n 0.9v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.0v 654.745n 0.0v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.9v 669.745n 0.9v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.0v 739.745n 0.0v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.0v 769.745n 0.0v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.0v 784.745n 0.0v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.0v 809.745n 0.0v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.0v 974.745n 0.0v 974.755n 0.9v 979.745n 0.9v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )

* Generation of wmask signals
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 0), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.9v 439.745n 0.9v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.9v 484.745n 0.9v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.9v 619.745n 0.9v 619.755n 0.9v 624.745n 0.9v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.9v 834.745n 0.9v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.9v 909.745n 0.9v 909.755n 0.9v 914.745n 0.9v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.9v 969.745n 0.9v 969.755n 0.9v 974.745n 0.9v 974.755n 0.9v 979.745n 0.9v 979.755n 0.9v 984.745n 0.9v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.9v 74.745n 0.9v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.9v 214.745n 0.9v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.0v 264.745n 0.0v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.9v 279.745n 0.9v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.9v 339.745n 0.9v 339.755n 0.9v 344.745n 0.9v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.9v 379.745n 0.9v 379.755n 0.9v 384.745n 0.9v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.9v 419.745n 0.9v 419.755n 0.9v 424.745n 0.9v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.9v 494.745n 0.9v 494.755n 0.9v 499.745n 0.9v 499.755n 0.0v 504.745n 0.0v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.9v 539.745n 0.9v 539.755n 0.9v 544.745n 0.9v 544.755n 0.9v 549.745n 0.9v 549.755n 0.9v 554.745n 0.9v 554.755n 0.0v 559.745n 0.0v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.0v 644.745n 0.0v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.9v 759.745n 0.9v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.9v 994.745n 0.9v 994.755n 0.0v 999.745n 0.0v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 1), (100, 1), (105, 1), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 1), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 0), (565, 0), (570, 1), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.0v 44.745n 0.0v 44.755n 0.9v 49.745n 0.9v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.0v 114.745n 0.0v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.0v 289.745n 0.0v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.9v 334.745n 0.9v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.9v 399.745n 0.9v 399.755n 0.0v 404.745n 0.0v 404.755n 0.9v 409.745n 0.9v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.9v 434.745n 0.9v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.9v 449.745n 0.9v 449.755n 0.9v 454.745n 0.9v 454.755n 0.9v 459.745n 0.9v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.9v 574.745n 0.9v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.9v 629.745n 0.9v 629.755n 0.9v 634.745n 0.9v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.9v 689.745n 0.9v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.0v 744.745n 0.0v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.9v 779.745n 0.9v 779.755n 0.9v 784.745n 0.9v 784.755n 0.9v 789.745n 0.9v 789.755n 0.9v 794.745n 0.9v 794.755n 0.9v 799.745n 0.9v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.0v 824.745n 0.0v 824.755n 0.9v 829.745n 0.9v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.9v 849.745n 0.9v 849.755n 0.9v 854.745n 0.9v 854.755n 0.9v 859.745n 0.9v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.9v 904.745n 0.9v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.9v 919.745n 0.9v 919.755n 0.0v 924.745n 0.0v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.9v 944.745n 0.9v 944.755n 0.9v 949.745n 0.9v 949.755n 0.0v 954.745n 0.0v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.9v 1019.745n 0.9v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 0), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 1), (1025, 1)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.9v 9.745n 0.9v 9.755n 0.9v 14.745n 0.9v 14.755n 0.9v 19.745n 0.9v 19.755n 0.9v 24.745n 0.9v 24.755n 0.9v 29.745n 0.9v 29.755n 0.9v 34.745n 0.9v 34.755n 0.9v 39.745n 0.9v 39.755n 0.9v 44.745n 0.9v 44.755n 0.0v 49.745n 0.0v 49.755n 0.9v 54.745n 0.9v 54.755n 0.9v 59.745n 0.9v 59.755n 0.9v 64.745n 0.9v 64.755n 0.9v 69.745n 0.9v 69.755n 0.0v 74.745n 0.0v 74.755n 0.9v 79.745n 0.9v 79.755n 0.9v 84.745n 0.9v 84.755n 0.9v 89.745n 0.9v 89.755n 0.9v 94.745n 0.9v 94.755n 0.9v 99.745n 0.9v 99.755n 0.9v 104.745n 0.9v 104.755n 0.9v 109.745n 0.9v 109.755n 0.9v 114.745n 0.9v 114.755n 0.9v 119.745n 0.9v 119.755n 0.9v 124.745n 0.9v 124.755n 0.9v 129.745n 0.9v 129.755n 0.9v 134.745n 0.9v 134.755n 0.9v 139.745n 0.9v 139.755n 0.9v 144.745n 0.9v 144.755n 0.9v 149.745n 0.9v 149.755n 0.9v 154.745n 0.9v 154.755n 0.9v 159.745n 0.9v 159.755n 0.9v 164.745n 0.9v 164.755n 0.9v 169.745n 0.9v 169.755n 0.9v 174.745n 0.9v 174.755n 0.9v 179.745n 0.9v 179.755n 0.9v 184.745n 0.9v 184.755n 0.9v 189.745n 0.9v 189.755n 0.9v 194.745n 0.9v 194.755n 0.9v 199.745n 0.9v 199.755n 0.9v 204.745n 0.9v 204.755n 0.9v 209.745n 0.9v 209.755n 0.0v 214.745n 0.0v 214.755n 0.9v 219.745n 0.9v 219.755n 0.9v 224.745n 0.9v 224.755n 0.9v 229.745n 0.9v 229.755n 0.9v 234.745n 0.9v 234.755n 0.9v 239.745n 0.9v 239.755n 0.9v 244.745n 0.9v 244.755n 0.9v 249.745n 0.9v 249.755n 0.9v 254.745n 0.9v 254.755n 0.9v 259.745n 0.9v 259.755n 0.9v 264.745n 0.9v 264.755n 0.9v 269.745n 0.9v 269.755n 0.9v 274.745n 0.9v 274.755n 0.0v 279.745n 0.0v 279.755n 0.9v 284.745n 0.9v 284.755n 0.9v 289.745n 0.9v 289.755n 0.9v 294.745n 0.9v 294.755n 0.9v 299.745n 0.9v 299.755n 0.9v 304.745n 0.9v 304.755n 0.9v 309.745n 0.9v 309.755n 0.9v 314.745n 0.9v 314.755n 0.9v 319.745n 0.9v 319.755n 0.9v 324.745n 0.9v 324.755n 0.9v 329.745n 0.9v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.9v 349.745n 0.9v 349.755n 0.9v 354.745n 0.9v 354.755n 0.9v 359.745n 0.9v 359.755n 0.9v 364.745n 0.9v 364.755n 0.9v 369.745n 0.9v 369.755n 0.9v 374.745n 0.9v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.9v 389.745n 0.9v 389.755n 0.9v 394.745n 0.9v 394.755n 0.0v 399.745n 0.0v 399.755n 0.9v 404.745n 0.9v 404.755n 0.9v 409.745n 0.9v 409.755n 0.9v 414.745n 0.9v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.9v 429.745n 0.9v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.9v 444.745n 0.9v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.9v 464.745n 0.9v 464.755n 0.9v 469.745n 0.9v 469.755n 0.9v 474.745n 0.9v 474.755n 0.9v 479.745n 0.9v 479.755n 0.0v 484.745n 0.0v 484.755n 0.9v 489.745n 0.9v 489.755n 0.0v 494.745n 0.0v 494.755n 0.9v 499.745n 0.9v 499.755n 0.9v 504.745n 0.9v 504.755n 0.9v 509.745n 0.9v 509.755n 0.9v 514.745n 0.9v 514.755n 0.9v 519.745n 0.9v 519.755n 0.9v 524.745n 0.9v 524.755n 0.9v 529.745n 0.9v 529.755n 0.9v 534.745n 0.9v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.9v 554.745n 0.9v 554.755n 0.9v 559.745n 0.9v 559.755n 0.9v 564.745n 0.9v 564.755n 0.9v 569.745n 0.9v 569.755n 0.0v 574.745n 0.0v 574.755n 0.9v 579.745n 0.9v 579.755n 0.9v 584.745n 0.9v 584.755n 0.9v 589.745n 0.9v 589.755n 0.9v 594.745n 0.9v 594.755n 0.9v 599.745n 0.9v 599.755n 0.9v 604.745n 0.9v 604.755n 0.9v 609.745n 0.9v 609.755n 0.9v 614.745n 0.9v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.9v 639.745n 0.9v 639.755n 0.9v 644.745n 0.9v 644.755n 0.9v 649.745n 0.9v 649.755n 0.9v 654.745n 0.9v 654.755n 0.9v 659.745n 0.9v 659.755n 0.9v 664.745n 0.9v 664.755n 0.9v 669.745n 0.9v 669.755n 0.9v 674.745n 0.9v 674.755n 0.9v 679.745n 0.9v 679.755n 0.9v 684.745n 0.9v 684.755n 0.0v 689.745n 0.0v 689.755n 0.9v 694.745n 0.9v 694.755n 0.9v 699.745n 0.9v 699.755n 0.9v 704.745n 0.9v 704.755n 0.9v 709.745n 0.9v 709.755n 0.9v 714.745n 0.9v 714.755n 0.9v 719.745n 0.9v 719.755n 0.9v 724.745n 0.9v 724.755n 0.9v 729.745n 0.9v 729.755n 0.9v 734.745n 0.9v 734.755n 0.9v 739.745n 0.9v 739.755n 0.9v 744.745n 0.9v 744.755n 0.9v 749.745n 0.9v 749.755n 0.9v 754.745n 0.9v 754.755n 0.0v 759.745n 0.0v 759.755n 0.9v 764.745n 0.9v 764.755n 0.9v 769.745n 0.9v 769.755n 0.9v 774.745n 0.9v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.9v 804.745n 0.9v 804.755n 0.9v 809.745n 0.9v 809.755n 0.9v 814.745n 0.9v 814.755n 0.9v 819.745n 0.9v 819.755n 0.9v 824.745n 0.9v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.9v 839.745n 0.9v 839.755n 0.9v 844.745n 0.9v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.9v 864.745n 0.9v 864.755n 0.9v 869.745n 0.9v 869.755n 0.9v 874.745n 0.9v 874.755n 0.9v 879.745n 0.9v 879.755n 0.9v 884.745n 0.9v 884.755n 0.9v 889.745n 0.9v 889.755n 0.9v 894.745n 0.9v 894.755n 0.9v 899.745n 0.9v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.9v 924.745n 0.9v 924.755n 0.9v 929.745n 0.9v 929.755n 0.9v 934.745n 0.9v 934.755n 0.9v 939.745n 0.9v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.9v 954.745n 0.9v 954.755n 0.9v 959.745n 0.9v 959.755n 0.9v 964.745n 0.9v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.9v 989.745n 0.9v 989.755n 0.0v 994.745n 0.0v 994.755n 0.9v 999.745n 0.9v 999.755n 0.9v 1004.745n 0.9v 1004.755n 0.9v 1009.745n 0.9v 1009.755n 0.9v 1014.745n 0.9v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.9v 1024.745n 0.9v 1024.755n 0.9v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)
* PULSE: period=5
Vclk1 clk1 0 PULSE (0 0.9 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout1_0 Vdout1_0ck4 = 0.9 time = 25
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=25.025n

* CHECK dout1_1 Vdout1_1ck4 = 0.9 time = 25
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=25.025n

* CHECK dout1_2 Vdout1_2ck4 = 0.9 time = 25
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=25.025n

* CHECK dout1_3 Vdout1_3ck4 = 0.9 time = 25
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=25.025n

* CHECK dout1_4 Vdout1_4ck4 = 0.9 time = 25
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=25.025n

* CHECK dout1_5 Vdout1_5ck4 = 0.9 time = 25
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=25.025n

* CHECK dout1_6 Vdout1_6ck4 = 0.9 time = 25
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=25.025n

* CHECK dout1_7 Vdout1_7ck4 = 0.9 time = 25
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=25.025n

* CHECK dout1_8 Vdout1_8ck4 = 0.9 time = 25
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=25.025n

* CHECK dout1_9 Vdout1_9ck4 = 0.9 time = 25
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=25.025n

* CHECK dout1_10 Vdout1_10ck4 = 0 time = 25
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=25.025n

* CHECK dout1_11 Vdout1_11ck4 = 0 time = 25
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=25.025n

* CHECK dout1_12 Vdout1_12ck4 = 0.9 time = 25
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=25.025n

* CHECK dout1_13 Vdout1_13ck4 = 0 time = 25
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=25.025n

* CHECK dout1_14 Vdout1_14ck4 = 0 time = 25
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=25.025n

* CHECK dout1_15 Vdout1_15ck4 = 0.9 time = 25
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=25.025n

* CHECK dout1_16 Vdout1_16ck4 = 0.9 time = 25
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=25.025n

* CHECK dout1_17 Vdout1_17ck4 = 0 time = 25
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=25.025n

* CHECK dout1_18 Vdout1_18ck4 = 0.9 time = 25
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=25.025n

* CHECK dout1_19 Vdout1_19ck4 = 0.9 time = 25
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=25.025n

* CHECK dout1_20 Vdout1_20ck4 = 0.9 time = 25
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=25.025n

* CHECK dout1_21 Vdout1_21ck4 = 0.9 time = 25
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=25.025n

* CHECK dout1_22 Vdout1_22ck4 = 0 time = 25
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=25.025n

* CHECK dout1_23 Vdout1_23ck4 = 0.9 time = 25
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=25.025n

* CHECK dout1_24 Vdout1_24ck4 = 0 time = 25
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=25.025n

* CHECK dout1_25 Vdout1_25ck4 = 0.9 time = 25
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=25.025n

* CHECK dout1_26 Vdout1_26ck4 = 0 time = 25
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=25.025n

* CHECK dout1_27 Vdout1_27ck4 = 0.9 time = 25
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=25.025n

* CHECK dout1_28 Vdout1_28ck4 = 0 time = 25
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=25.025n

* CHECK dout1_29 Vdout1_29ck4 = 0.9 time = 25
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=25.025n

* CHECK dout1_30 Vdout1_30ck4 = 0 time = 25
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=25.025n

* CHECK dout1_31 Vdout1_31ck4 = 0 time = 25
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=25.025n

* CHECK dout1_32 Vdout1_32ck4 = 0.9 time = 25
.meas tran vdout1_32ck4 FIND v(dout1_32) AT=25.025n

* CHECK dout1_33 Vdout1_33ck4 = 0.9 time = 25
.meas tran vdout1_33ck4 FIND v(dout1_33) AT=25.025n

* CHECK dout1_34 Vdout1_34ck4 = 0.9 time = 25
.meas tran vdout1_34ck4 FIND v(dout1_34) AT=25.025n

* CHECK dout1_35 Vdout1_35ck4 = 0.9 time = 25
.meas tran vdout1_35ck4 FIND v(dout1_35) AT=25.025n

* CHECK dout1_36 Vdout1_36ck4 = 0 time = 25
.meas tran vdout1_36ck4 FIND v(dout1_36) AT=25.025n

* CHECK dout1_37 Vdout1_37ck4 = 0 time = 25
.meas tran vdout1_37ck4 FIND v(dout1_37) AT=25.025n

* CHECK dout1_38 Vdout1_38ck4 = 0.9 time = 25
.meas tran vdout1_38ck4 FIND v(dout1_38) AT=25.025n

* CHECK dout1_39 Vdout1_39ck4 = 0.9 time = 25
.meas tran vdout1_39ck4 FIND v(dout1_39) AT=25.025n

* CHECK dout1_40 Vdout1_40ck4 = 0 time = 25
.meas tran vdout1_40ck4 FIND v(dout1_40) AT=25.025n

* CHECK dout1_41 Vdout1_41ck4 = 0.9 time = 25
.meas tran vdout1_41ck4 FIND v(dout1_41) AT=25.025n

* CHECK dout1_42 Vdout1_42ck4 = 0.9 time = 25
.meas tran vdout1_42ck4 FIND v(dout1_42) AT=25.025n

* CHECK dout1_43 Vdout1_43ck4 = 0.9 time = 25
.meas tran vdout1_43ck4 FIND v(dout1_43) AT=25.025n

* CHECK dout1_44 Vdout1_44ck4 = 0.9 time = 25
.meas tran vdout1_44ck4 FIND v(dout1_44) AT=25.025n

* CHECK dout1_45 Vdout1_45ck4 = 0.9 time = 25
.meas tran vdout1_45ck4 FIND v(dout1_45) AT=25.025n

* CHECK dout1_46 Vdout1_46ck4 = 0.9 time = 25
.meas tran vdout1_46ck4 FIND v(dout1_46) AT=25.025n

* CHECK dout1_47 Vdout1_47ck4 = 0 time = 25
.meas tran vdout1_47ck4 FIND v(dout1_47) AT=25.025n

* CHECK dout1_48 Vdout1_48ck4 = 0.9 time = 25
.meas tran vdout1_48ck4 FIND v(dout1_48) AT=25.025n

* CHECK dout1_49 Vdout1_49ck4 = 0 time = 25
.meas tran vdout1_49ck4 FIND v(dout1_49) AT=25.025n

* CHECK dout1_50 Vdout1_50ck4 = 0 time = 25
.meas tran vdout1_50ck4 FIND v(dout1_50) AT=25.025n

* CHECK dout1_51 Vdout1_51ck4 = 0 time = 25
.meas tran vdout1_51ck4 FIND v(dout1_51) AT=25.025n

* CHECK dout1_52 Vdout1_52ck4 = 0.9 time = 25
.meas tran vdout1_52ck4 FIND v(dout1_52) AT=25.025n

* CHECK dout1_53 Vdout1_53ck4 = 0 time = 25
.meas tran vdout1_53ck4 FIND v(dout1_53) AT=25.025n

* CHECK dout1_54 Vdout1_54ck4 = 0.9 time = 25
.meas tran vdout1_54ck4 FIND v(dout1_54) AT=25.025n

* CHECK dout1_55 Vdout1_55ck4 = 0 time = 25
.meas tran vdout1_55ck4 FIND v(dout1_55) AT=25.025n

* CHECK dout1_56 Vdout1_56ck4 = 0.9 time = 25
.meas tran vdout1_56ck4 FIND v(dout1_56) AT=25.025n

* CHECK dout1_57 Vdout1_57ck4 = 0.9 time = 25
.meas tran vdout1_57ck4 FIND v(dout1_57) AT=25.025n

* CHECK dout1_58 Vdout1_58ck4 = 0.9 time = 25
.meas tran vdout1_58ck4 FIND v(dout1_58) AT=25.025n

* CHECK dout1_59 Vdout1_59ck4 = 0 time = 25
.meas tran vdout1_59ck4 FIND v(dout1_59) AT=25.025n

* CHECK dout1_60 Vdout1_60ck4 = 0.9 time = 25
.meas tran vdout1_60ck4 FIND v(dout1_60) AT=25.025n

* CHECK dout1_61 Vdout1_61ck4 = 0.9 time = 25
.meas tran vdout1_61ck4 FIND v(dout1_61) AT=25.025n

* CHECK dout1_62 Vdout1_62ck4 = 0 time = 25
.meas tran vdout1_62ck4 FIND v(dout1_62) AT=25.025n

* CHECK dout1_63 Vdout1_63ck4 = 0 time = 25
.meas tran vdout1_63ck4 FIND v(dout1_63) AT=25.025n

* CHECK dout1_64 Vdout1_64ck4 = 0.9 time = 25
.meas tran vdout1_64ck4 FIND v(dout1_64) AT=25.025n

* CHECK dout1_65 Vdout1_65ck4 = 0 time = 25
.meas tran vdout1_65ck4 FIND v(dout1_65) AT=25.025n

* CHECK dout1_66 Vdout1_66ck4 = 0 time = 25
.meas tran vdout1_66ck4 FIND v(dout1_66) AT=25.025n

* CHECK dout1_67 Vdout1_67ck4 = 0.9 time = 25
.meas tran vdout1_67ck4 FIND v(dout1_67) AT=25.025n

* CHECK dout1_68 Vdout1_68ck4 = 0.9 time = 25
.meas tran vdout1_68ck4 FIND v(dout1_68) AT=25.025n

* CHECK dout1_69 Vdout1_69ck4 = 0.9 time = 25
.meas tran vdout1_69ck4 FIND v(dout1_69) AT=25.025n

* CHECK dout1_70 Vdout1_70ck4 = 0 time = 25
.meas tran vdout1_70ck4 FIND v(dout1_70) AT=25.025n

* CHECK dout1_71 Vdout1_71ck4 = 0 time = 25
.meas tran vdout1_71ck4 FIND v(dout1_71) AT=25.025n

* CHECK dout1_72 Vdout1_72ck4 = 0.9 time = 25
.meas tran vdout1_72ck4 FIND v(dout1_72) AT=25.025n

* CHECK dout1_73 Vdout1_73ck4 = 0 time = 25
.meas tran vdout1_73ck4 FIND v(dout1_73) AT=25.025n

* CHECK dout1_74 Vdout1_74ck4 = 0 time = 25
.meas tran vdout1_74ck4 FIND v(dout1_74) AT=25.025n

* CHECK dout1_75 Vdout1_75ck4 = 0.9 time = 25
.meas tran vdout1_75ck4 FIND v(dout1_75) AT=25.025n

* CHECK dout1_76 Vdout1_76ck4 = 0.9 time = 25
.meas tran vdout1_76ck4 FIND v(dout1_76) AT=25.025n

* CHECK dout1_77 Vdout1_77ck4 = 0 time = 25
.meas tran vdout1_77ck4 FIND v(dout1_77) AT=25.025n

* CHECK dout1_78 Vdout1_78ck4 = 0.9 time = 25
.meas tran vdout1_78ck4 FIND v(dout1_78) AT=25.025n

* CHECK dout1_79 Vdout1_79ck4 = 0 time = 25
.meas tran vdout1_79ck4 FIND v(dout1_79) AT=25.025n

* CHECK dout1_80 Vdout1_80ck4 = 0 time = 25
.meas tran vdout1_80ck4 FIND v(dout1_80) AT=25.025n

* CHECK dout1_81 Vdout1_81ck4 = 0.9 time = 25
.meas tran vdout1_81ck4 FIND v(dout1_81) AT=25.025n

* CHECK dout1_82 Vdout1_82ck4 = 0 time = 25
.meas tran vdout1_82ck4 FIND v(dout1_82) AT=25.025n

* CHECK dout1_83 Vdout1_83ck4 = 0 time = 25
.meas tran vdout1_83ck4 FIND v(dout1_83) AT=25.025n

* CHECK dout1_84 Vdout1_84ck4 = 0.9 time = 25
.meas tran vdout1_84ck4 FIND v(dout1_84) AT=25.025n

* CHECK dout1_85 Vdout1_85ck4 = 0.9 time = 25
.meas tran vdout1_85ck4 FIND v(dout1_85) AT=25.025n

* CHECK dout1_86 Vdout1_86ck4 = 0.9 time = 25
.meas tran vdout1_86ck4 FIND v(dout1_86) AT=25.025n

* CHECK dout1_87 Vdout1_87ck4 = 0.9 time = 25
.meas tran vdout1_87ck4 FIND v(dout1_87) AT=25.025n

* CHECK dout1_88 Vdout1_88ck4 = 0 time = 25
.meas tran vdout1_88ck4 FIND v(dout1_88) AT=25.025n

* CHECK dout1_89 Vdout1_89ck4 = 0 time = 25
.meas tran vdout1_89ck4 FIND v(dout1_89) AT=25.025n

* CHECK dout1_90 Vdout1_90ck4 = 0 time = 25
.meas tran vdout1_90ck4 FIND v(dout1_90) AT=25.025n

* CHECK dout1_91 Vdout1_91ck4 = 0 time = 25
.meas tran vdout1_91ck4 FIND v(dout1_91) AT=25.025n

* CHECK dout1_92 Vdout1_92ck4 = 0.9 time = 25
.meas tran vdout1_92ck4 FIND v(dout1_92) AT=25.025n

* CHECK dout1_93 Vdout1_93ck4 = 0 time = 25
.meas tran vdout1_93ck4 FIND v(dout1_93) AT=25.025n

* CHECK dout1_94 Vdout1_94ck4 = 0 time = 25
.meas tran vdout1_94ck4 FIND v(dout1_94) AT=25.025n

* CHECK dout1_95 Vdout1_95ck4 = 0 time = 25
.meas tran vdout1_95ck4 FIND v(dout1_95) AT=25.025n

* CHECK dout1_96 Vdout1_96ck4 = 0 time = 25
.meas tran vdout1_96ck4 FIND v(dout1_96) AT=25.025n

* CHECK dout1_97 Vdout1_97ck4 = 0.9 time = 25
.meas tran vdout1_97ck4 FIND v(dout1_97) AT=25.025n

* CHECK dout1_98 Vdout1_98ck4 = 0 time = 25
.meas tran vdout1_98ck4 FIND v(dout1_98) AT=25.025n

* CHECK dout1_99 Vdout1_99ck4 = 0 time = 25
.meas tran vdout1_99ck4 FIND v(dout1_99) AT=25.025n

* CHECK dout1_100 Vdout1_100ck4 = 0.9 time = 25
.meas tran vdout1_100ck4 FIND v(dout1_100) AT=25.025n

* CHECK dout1_101 Vdout1_101ck4 = 0 time = 25
.meas tran vdout1_101ck4 FIND v(dout1_101) AT=25.025n

* CHECK dout1_102 Vdout1_102ck4 = 0 time = 25
.meas tran vdout1_102ck4 FIND v(dout1_102) AT=25.025n

* CHECK dout1_103 Vdout1_103ck4 = 0.9 time = 25
.meas tran vdout1_103ck4 FIND v(dout1_103) AT=25.025n

* CHECK dout1_104 Vdout1_104ck4 = 0 time = 25
.meas tran vdout1_104ck4 FIND v(dout1_104) AT=25.025n

* CHECK dout1_105 Vdout1_105ck4 = 0.9 time = 25
.meas tran vdout1_105ck4 FIND v(dout1_105) AT=25.025n

* CHECK dout1_106 Vdout1_106ck4 = 0 time = 25
.meas tran vdout1_106ck4 FIND v(dout1_106) AT=25.025n

* CHECK dout1_107 Vdout1_107ck4 = 0.9 time = 25
.meas tran vdout1_107ck4 FIND v(dout1_107) AT=25.025n

* CHECK dout1_108 Vdout1_108ck4 = 0 time = 25
.meas tran vdout1_108ck4 FIND v(dout1_108) AT=25.025n

* CHECK dout1_109 Vdout1_109ck4 = 0.9 time = 25
.meas tran vdout1_109ck4 FIND v(dout1_109) AT=25.025n

* CHECK dout1_110 Vdout1_110ck4 = 0.9 time = 25
.meas tran vdout1_110ck4 FIND v(dout1_110) AT=25.025n

* CHECK dout1_111 Vdout1_111ck4 = 0.9 time = 25
.meas tran vdout1_111ck4 FIND v(dout1_111) AT=25.025n

* CHECK dout1_112 Vdout1_112ck4 = 0.9 time = 25
.meas tran vdout1_112ck4 FIND v(dout1_112) AT=25.025n

* CHECK dout1_113 Vdout1_113ck4 = 0.9 time = 25
.meas tran vdout1_113ck4 FIND v(dout1_113) AT=25.025n

* CHECK dout1_114 Vdout1_114ck4 = 0 time = 25
.meas tran vdout1_114ck4 FIND v(dout1_114) AT=25.025n

* CHECK dout1_115 Vdout1_115ck4 = 0.9 time = 25
.meas tran vdout1_115ck4 FIND v(dout1_115) AT=25.025n

* CHECK dout1_116 Vdout1_116ck4 = 0.9 time = 25
.meas tran vdout1_116ck4 FIND v(dout1_116) AT=25.025n

* CHECK dout1_117 Vdout1_117ck4 = 0 time = 25
.meas tran vdout1_117ck4 FIND v(dout1_117) AT=25.025n

* CHECK dout1_118 Vdout1_118ck4 = 0 time = 25
.meas tran vdout1_118ck4 FIND v(dout1_118) AT=25.025n

* CHECK dout1_119 Vdout1_119ck4 = 0 time = 25
.meas tran vdout1_119ck4 FIND v(dout1_119) AT=25.025n

* CHECK dout1_0 Vdout1_0ck5 = 0.9 time = 30
.meas tran vdout1_0ck5 FIND v(dout1_0) AT=30.025n

* CHECK dout1_1 Vdout1_1ck5 = 0.9 time = 30
.meas tran vdout1_1ck5 FIND v(dout1_1) AT=30.025n

* CHECK dout1_2 Vdout1_2ck5 = 0.9 time = 30
.meas tran vdout1_2ck5 FIND v(dout1_2) AT=30.025n

* CHECK dout1_3 Vdout1_3ck5 = 0.9 time = 30
.meas tran vdout1_3ck5 FIND v(dout1_3) AT=30.025n

* CHECK dout1_4 Vdout1_4ck5 = 0.9 time = 30
.meas tran vdout1_4ck5 FIND v(dout1_4) AT=30.025n

* CHECK dout1_5 Vdout1_5ck5 = 0.9 time = 30
.meas tran vdout1_5ck5 FIND v(dout1_5) AT=30.025n

* CHECK dout1_6 Vdout1_6ck5 = 0.9 time = 30
.meas tran vdout1_6ck5 FIND v(dout1_6) AT=30.025n

* CHECK dout1_7 Vdout1_7ck5 = 0.9 time = 30
.meas tran vdout1_7ck5 FIND v(dout1_7) AT=30.025n

* CHECK dout1_8 Vdout1_8ck5 = 0.9 time = 30
.meas tran vdout1_8ck5 FIND v(dout1_8) AT=30.025n

* CHECK dout1_9 Vdout1_9ck5 = 0.9 time = 30
.meas tran vdout1_9ck5 FIND v(dout1_9) AT=30.025n

* CHECK dout1_10 Vdout1_10ck5 = 0 time = 30
.meas tran vdout1_10ck5 FIND v(dout1_10) AT=30.025n

* CHECK dout1_11 Vdout1_11ck5 = 0 time = 30
.meas tran vdout1_11ck5 FIND v(dout1_11) AT=30.025n

* CHECK dout1_12 Vdout1_12ck5 = 0.9 time = 30
.meas tran vdout1_12ck5 FIND v(dout1_12) AT=30.025n

* CHECK dout1_13 Vdout1_13ck5 = 0 time = 30
.meas tran vdout1_13ck5 FIND v(dout1_13) AT=30.025n

* CHECK dout1_14 Vdout1_14ck5 = 0 time = 30
.meas tran vdout1_14ck5 FIND v(dout1_14) AT=30.025n

* CHECK dout1_15 Vdout1_15ck5 = 0.9 time = 30
.meas tran vdout1_15ck5 FIND v(dout1_15) AT=30.025n

* CHECK dout1_16 Vdout1_16ck5 = 0.9 time = 30
.meas tran vdout1_16ck5 FIND v(dout1_16) AT=30.025n

* CHECK dout1_17 Vdout1_17ck5 = 0 time = 30
.meas tran vdout1_17ck5 FIND v(dout1_17) AT=30.025n

* CHECK dout1_18 Vdout1_18ck5 = 0.9 time = 30
.meas tran vdout1_18ck5 FIND v(dout1_18) AT=30.025n

* CHECK dout1_19 Vdout1_19ck5 = 0.9 time = 30
.meas tran vdout1_19ck5 FIND v(dout1_19) AT=30.025n

* CHECK dout1_20 Vdout1_20ck5 = 0.9 time = 30
.meas tran vdout1_20ck5 FIND v(dout1_20) AT=30.025n

* CHECK dout1_21 Vdout1_21ck5 = 0.9 time = 30
.meas tran vdout1_21ck5 FIND v(dout1_21) AT=30.025n

* CHECK dout1_22 Vdout1_22ck5 = 0 time = 30
.meas tran vdout1_22ck5 FIND v(dout1_22) AT=30.025n

* CHECK dout1_23 Vdout1_23ck5 = 0.9 time = 30
.meas tran vdout1_23ck5 FIND v(dout1_23) AT=30.025n

* CHECK dout1_24 Vdout1_24ck5 = 0 time = 30
.meas tran vdout1_24ck5 FIND v(dout1_24) AT=30.025n

* CHECK dout1_25 Vdout1_25ck5 = 0.9 time = 30
.meas tran vdout1_25ck5 FIND v(dout1_25) AT=30.025n

* CHECK dout1_26 Vdout1_26ck5 = 0 time = 30
.meas tran vdout1_26ck5 FIND v(dout1_26) AT=30.025n

* CHECK dout1_27 Vdout1_27ck5 = 0.9 time = 30
.meas tran vdout1_27ck5 FIND v(dout1_27) AT=30.025n

* CHECK dout1_28 Vdout1_28ck5 = 0 time = 30
.meas tran vdout1_28ck5 FIND v(dout1_28) AT=30.025n

* CHECK dout1_29 Vdout1_29ck5 = 0.9 time = 30
.meas tran vdout1_29ck5 FIND v(dout1_29) AT=30.025n

* CHECK dout1_30 Vdout1_30ck5 = 0 time = 30
.meas tran vdout1_30ck5 FIND v(dout1_30) AT=30.025n

* CHECK dout1_31 Vdout1_31ck5 = 0 time = 30
.meas tran vdout1_31ck5 FIND v(dout1_31) AT=30.025n

* CHECK dout1_32 Vdout1_32ck5 = 0.9 time = 30
.meas tran vdout1_32ck5 FIND v(dout1_32) AT=30.025n

* CHECK dout1_33 Vdout1_33ck5 = 0.9 time = 30
.meas tran vdout1_33ck5 FIND v(dout1_33) AT=30.025n

* CHECK dout1_34 Vdout1_34ck5 = 0.9 time = 30
.meas tran vdout1_34ck5 FIND v(dout1_34) AT=30.025n

* CHECK dout1_35 Vdout1_35ck5 = 0.9 time = 30
.meas tran vdout1_35ck5 FIND v(dout1_35) AT=30.025n

* CHECK dout1_36 Vdout1_36ck5 = 0 time = 30
.meas tran vdout1_36ck5 FIND v(dout1_36) AT=30.025n

* CHECK dout1_37 Vdout1_37ck5 = 0 time = 30
.meas tran vdout1_37ck5 FIND v(dout1_37) AT=30.025n

* CHECK dout1_38 Vdout1_38ck5 = 0.9 time = 30
.meas tran vdout1_38ck5 FIND v(dout1_38) AT=30.025n

* CHECK dout1_39 Vdout1_39ck5 = 0.9 time = 30
.meas tran vdout1_39ck5 FIND v(dout1_39) AT=30.025n

* CHECK dout1_40 Vdout1_40ck5 = 0 time = 30
.meas tran vdout1_40ck5 FIND v(dout1_40) AT=30.025n

* CHECK dout1_41 Vdout1_41ck5 = 0.9 time = 30
.meas tran vdout1_41ck5 FIND v(dout1_41) AT=30.025n

* CHECK dout1_42 Vdout1_42ck5 = 0.9 time = 30
.meas tran vdout1_42ck5 FIND v(dout1_42) AT=30.025n

* CHECK dout1_43 Vdout1_43ck5 = 0.9 time = 30
.meas tran vdout1_43ck5 FIND v(dout1_43) AT=30.025n

* CHECK dout1_44 Vdout1_44ck5 = 0.9 time = 30
.meas tran vdout1_44ck5 FIND v(dout1_44) AT=30.025n

* CHECK dout1_45 Vdout1_45ck5 = 0.9 time = 30
.meas tran vdout1_45ck5 FIND v(dout1_45) AT=30.025n

* CHECK dout1_46 Vdout1_46ck5 = 0.9 time = 30
.meas tran vdout1_46ck5 FIND v(dout1_46) AT=30.025n

* CHECK dout1_47 Vdout1_47ck5 = 0 time = 30
.meas tran vdout1_47ck5 FIND v(dout1_47) AT=30.025n

* CHECK dout1_48 Vdout1_48ck5 = 0.9 time = 30
.meas tran vdout1_48ck5 FIND v(dout1_48) AT=30.025n

* CHECK dout1_49 Vdout1_49ck5 = 0 time = 30
.meas tran vdout1_49ck5 FIND v(dout1_49) AT=30.025n

* CHECK dout1_50 Vdout1_50ck5 = 0 time = 30
.meas tran vdout1_50ck5 FIND v(dout1_50) AT=30.025n

* CHECK dout1_51 Vdout1_51ck5 = 0 time = 30
.meas tran vdout1_51ck5 FIND v(dout1_51) AT=30.025n

* CHECK dout1_52 Vdout1_52ck5 = 0.9 time = 30
.meas tran vdout1_52ck5 FIND v(dout1_52) AT=30.025n

* CHECK dout1_53 Vdout1_53ck5 = 0 time = 30
.meas tran vdout1_53ck5 FIND v(dout1_53) AT=30.025n

* CHECK dout1_54 Vdout1_54ck5 = 0.9 time = 30
.meas tran vdout1_54ck5 FIND v(dout1_54) AT=30.025n

* CHECK dout1_55 Vdout1_55ck5 = 0 time = 30
.meas tran vdout1_55ck5 FIND v(dout1_55) AT=30.025n

* CHECK dout1_56 Vdout1_56ck5 = 0.9 time = 30
.meas tran vdout1_56ck5 FIND v(dout1_56) AT=30.025n

* CHECK dout1_57 Vdout1_57ck5 = 0.9 time = 30
.meas tran vdout1_57ck5 FIND v(dout1_57) AT=30.025n

* CHECK dout1_58 Vdout1_58ck5 = 0.9 time = 30
.meas tran vdout1_58ck5 FIND v(dout1_58) AT=30.025n

* CHECK dout1_59 Vdout1_59ck5 = 0 time = 30
.meas tran vdout1_59ck5 FIND v(dout1_59) AT=30.025n

* CHECK dout1_60 Vdout1_60ck5 = 0.9 time = 30
.meas tran vdout1_60ck5 FIND v(dout1_60) AT=30.025n

* CHECK dout1_61 Vdout1_61ck5 = 0.9 time = 30
.meas tran vdout1_61ck5 FIND v(dout1_61) AT=30.025n

* CHECK dout1_62 Vdout1_62ck5 = 0 time = 30
.meas tran vdout1_62ck5 FIND v(dout1_62) AT=30.025n

* CHECK dout1_63 Vdout1_63ck5 = 0 time = 30
.meas tran vdout1_63ck5 FIND v(dout1_63) AT=30.025n

* CHECK dout1_64 Vdout1_64ck5 = 0.9 time = 30
.meas tran vdout1_64ck5 FIND v(dout1_64) AT=30.025n

* CHECK dout1_65 Vdout1_65ck5 = 0 time = 30
.meas tran vdout1_65ck5 FIND v(dout1_65) AT=30.025n

* CHECK dout1_66 Vdout1_66ck5 = 0 time = 30
.meas tran vdout1_66ck5 FIND v(dout1_66) AT=30.025n

* CHECK dout1_67 Vdout1_67ck5 = 0.9 time = 30
.meas tran vdout1_67ck5 FIND v(dout1_67) AT=30.025n

* CHECK dout1_68 Vdout1_68ck5 = 0.9 time = 30
.meas tran vdout1_68ck5 FIND v(dout1_68) AT=30.025n

* CHECK dout1_69 Vdout1_69ck5 = 0.9 time = 30
.meas tran vdout1_69ck5 FIND v(dout1_69) AT=30.025n

* CHECK dout1_70 Vdout1_70ck5 = 0 time = 30
.meas tran vdout1_70ck5 FIND v(dout1_70) AT=30.025n

* CHECK dout1_71 Vdout1_71ck5 = 0 time = 30
.meas tran vdout1_71ck5 FIND v(dout1_71) AT=30.025n

* CHECK dout1_72 Vdout1_72ck5 = 0.9 time = 30
.meas tran vdout1_72ck5 FIND v(dout1_72) AT=30.025n

* CHECK dout1_73 Vdout1_73ck5 = 0 time = 30
.meas tran vdout1_73ck5 FIND v(dout1_73) AT=30.025n

* CHECK dout1_74 Vdout1_74ck5 = 0 time = 30
.meas tran vdout1_74ck5 FIND v(dout1_74) AT=30.025n

* CHECK dout1_75 Vdout1_75ck5 = 0.9 time = 30
.meas tran vdout1_75ck5 FIND v(dout1_75) AT=30.025n

* CHECK dout1_76 Vdout1_76ck5 = 0.9 time = 30
.meas tran vdout1_76ck5 FIND v(dout1_76) AT=30.025n

* CHECK dout1_77 Vdout1_77ck5 = 0 time = 30
.meas tran vdout1_77ck5 FIND v(dout1_77) AT=30.025n

* CHECK dout1_78 Vdout1_78ck5 = 0.9 time = 30
.meas tran vdout1_78ck5 FIND v(dout1_78) AT=30.025n

* CHECK dout1_79 Vdout1_79ck5 = 0 time = 30
.meas tran vdout1_79ck5 FIND v(dout1_79) AT=30.025n

* CHECK dout1_80 Vdout1_80ck5 = 0 time = 30
.meas tran vdout1_80ck5 FIND v(dout1_80) AT=30.025n

* CHECK dout1_81 Vdout1_81ck5 = 0.9 time = 30
.meas tran vdout1_81ck5 FIND v(dout1_81) AT=30.025n

* CHECK dout1_82 Vdout1_82ck5 = 0 time = 30
.meas tran vdout1_82ck5 FIND v(dout1_82) AT=30.025n

* CHECK dout1_83 Vdout1_83ck5 = 0 time = 30
.meas tran vdout1_83ck5 FIND v(dout1_83) AT=30.025n

* CHECK dout1_84 Vdout1_84ck5 = 0.9 time = 30
.meas tran vdout1_84ck5 FIND v(dout1_84) AT=30.025n

* CHECK dout1_85 Vdout1_85ck5 = 0.9 time = 30
.meas tran vdout1_85ck5 FIND v(dout1_85) AT=30.025n

* CHECK dout1_86 Vdout1_86ck5 = 0.9 time = 30
.meas tran vdout1_86ck5 FIND v(dout1_86) AT=30.025n

* CHECK dout1_87 Vdout1_87ck5 = 0.9 time = 30
.meas tran vdout1_87ck5 FIND v(dout1_87) AT=30.025n

* CHECK dout1_88 Vdout1_88ck5 = 0 time = 30
.meas tran vdout1_88ck5 FIND v(dout1_88) AT=30.025n

* CHECK dout1_89 Vdout1_89ck5 = 0 time = 30
.meas tran vdout1_89ck5 FIND v(dout1_89) AT=30.025n

* CHECK dout1_90 Vdout1_90ck5 = 0 time = 30
.meas tran vdout1_90ck5 FIND v(dout1_90) AT=30.025n

* CHECK dout1_91 Vdout1_91ck5 = 0 time = 30
.meas tran vdout1_91ck5 FIND v(dout1_91) AT=30.025n

* CHECK dout1_92 Vdout1_92ck5 = 0.9 time = 30
.meas tran vdout1_92ck5 FIND v(dout1_92) AT=30.025n

* CHECK dout1_93 Vdout1_93ck5 = 0 time = 30
.meas tran vdout1_93ck5 FIND v(dout1_93) AT=30.025n

* CHECK dout1_94 Vdout1_94ck5 = 0 time = 30
.meas tran vdout1_94ck5 FIND v(dout1_94) AT=30.025n

* CHECK dout1_95 Vdout1_95ck5 = 0 time = 30
.meas tran vdout1_95ck5 FIND v(dout1_95) AT=30.025n

* CHECK dout1_96 Vdout1_96ck5 = 0 time = 30
.meas tran vdout1_96ck5 FIND v(dout1_96) AT=30.025n

* CHECK dout1_97 Vdout1_97ck5 = 0.9 time = 30
.meas tran vdout1_97ck5 FIND v(dout1_97) AT=30.025n

* CHECK dout1_98 Vdout1_98ck5 = 0 time = 30
.meas tran vdout1_98ck5 FIND v(dout1_98) AT=30.025n

* CHECK dout1_99 Vdout1_99ck5 = 0 time = 30
.meas tran vdout1_99ck5 FIND v(dout1_99) AT=30.025n

* CHECK dout1_100 Vdout1_100ck5 = 0.9 time = 30
.meas tran vdout1_100ck5 FIND v(dout1_100) AT=30.025n

* CHECK dout1_101 Vdout1_101ck5 = 0 time = 30
.meas tran vdout1_101ck5 FIND v(dout1_101) AT=30.025n

* CHECK dout1_102 Vdout1_102ck5 = 0 time = 30
.meas tran vdout1_102ck5 FIND v(dout1_102) AT=30.025n

* CHECK dout1_103 Vdout1_103ck5 = 0.9 time = 30
.meas tran vdout1_103ck5 FIND v(dout1_103) AT=30.025n

* CHECK dout1_104 Vdout1_104ck5 = 0 time = 30
.meas tran vdout1_104ck5 FIND v(dout1_104) AT=30.025n

* CHECK dout1_105 Vdout1_105ck5 = 0.9 time = 30
.meas tran vdout1_105ck5 FIND v(dout1_105) AT=30.025n

* CHECK dout1_106 Vdout1_106ck5 = 0 time = 30
.meas tran vdout1_106ck5 FIND v(dout1_106) AT=30.025n

* CHECK dout1_107 Vdout1_107ck5 = 0.9 time = 30
.meas tran vdout1_107ck5 FIND v(dout1_107) AT=30.025n

* CHECK dout1_108 Vdout1_108ck5 = 0 time = 30
.meas tran vdout1_108ck5 FIND v(dout1_108) AT=30.025n

* CHECK dout1_109 Vdout1_109ck5 = 0.9 time = 30
.meas tran vdout1_109ck5 FIND v(dout1_109) AT=30.025n

* CHECK dout1_110 Vdout1_110ck5 = 0.9 time = 30
.meas tran vdout1_110ck5 FIND v(dout1_110) AT=30.025n

* CHECK dout1_111 Vdout1_111ck5 = 0.9 time = 30
.meas tran vdout1_111ck5 FIND v(dout1_111) AT=30.025n

* CHECK dout1_112 Vdout1_112ck5 = 0.9 time = 30
.meas tran vdout1_112ck5 FIND v(dout1_112) AT=30.025n

* CHECK dout1_113 Vdout1_113ck5 = 0.9 time = 30
.meas tran vdout1_113ck5 FIND v(dout1_113) AT=30.025n

* CHECK dout1_114 Vdout1_114ck5 = 0 time = 30
.meas tran vdout1_114ck5 FIND v(dout1_114) AT=30.025n

* CHECK dout1_115 Vdout1_115ck5 = 0.9 time = 30
.meas tran vdout1_115ck5 FIND v(dout1_115) AT=30.025n

* CHECK dout1_116 Vdout1_116ck5 = 0.9 time = 30
.meas tran vdout1_116ck5 FIND v(dout1_116) AT=30.025n

* CHECK dout1_117 Vdout1_117ck5 = 0 time = 30
.meas tran vdout1_117ck5 FIND v(dout1_117) AT=30.025n

* CHECK dout1_118 Vdout1_118ck5 = 0 time = 30
.meas tran vdout1_118ck5 FIND v(dout1_118) AT=30.025n

* CHECK dout1_119 Vdout1_119ck5 = 0 time = 30
.meas tran vdout1_119ck5 FIND v(dout1_119) AT=30.025n

* CHECK dout1_0 Vdout1_0ck6 = 0.9 time = 35
.meas tran vdout1_0ck6 FIND v(dout1_0) AT=35.025n

* CHECK dout1_1 Vdout1_1ck6 = 0.9 time = 35
.meas tran vdout1_1ck6 FIND v(dout1_1) AT=35.025n

* CHECK dout1_2 Vdout1_2ck6 = 0 time = 35
.meas tran vdout1_2ck6 FIND v(dout1_2) AT=35.025n

* CHECK dout1_3 Vdout1_3ck6 = 0.9 time = 35
.meas tran vdout1_3ck6 FIND v(dout1_3) AT=35.025n

* CHECK dout1_4 Vdout1_4ck6 = 0 time = 35
.meas tran vdout1_4ck6 FIND v(dout1_4) AT=35.025n

* CHECK dout1_5 Vdout1_5ck6 = 0 time = 35
.meas tran vdout1_5ck6 FIND v(dout1_5) AT=35.025n

* CHECK dout1_6 Vdout1_6ck6 = 0.9 time = 35
.meas tran vdout1_6ck6 FIND v(dout1_6) AT=35.025n

* CHECK dout1_7 Vdout1_7ck6 = 0.9 time = 35
.meas tran vdout1_7ck6 FIND v(dout1_7) AT=35.025n

* CHECK dout1_8 Vdout1_8ck6 = 0 time = 35
.meas tran vdout1_8ck6 FIND v(dout1_8) AT=35.025n

* CHECK dout1_9 Vdout1_9ck6 = 0.9 time = 35
.meas tran vdout1_9ck6 FIND v(dout1_9) AT=35.025n

* CHECK dout1_10 Vdout1_10ck6 = 0.9 time = 35
.meas tran vdout1_10ck6 FIND v(dout1_10) AT=35.025n

* CHECK dout1_11 Vdout1_11ck6 = 0.9 time = 35
.meas tran vdout1_11ck6 FIND v(dout1_11) AT=35.025n

* CHECK dout1_12 Vdout1_12ck6 = 0.9 time = 35
.meas tran vdout1_12ck6 FIND v(dout1_12) AT=35.025n

* CHECK dout1_13 Vdout1_13ck6 = 0.9 time = 35
.meas tran vdout1_13ck6 FIND v(dout1_13) AT=35.025n

* CHECK dout1_14 Vdout1_14ck6 = 0 time = 35
.meas tran vdout1_14ck6 FIND v(dout1_14) AT=35.025n

* CHECK dout1_15 Vdout1_15ck6 = 0 time = 35
.meas tran vdout1_15ck6 FIND v(dout1_15) AT=35.025n

* CHECK dout1_16 Vdout1_16ck6 = 0.9 time = 35
.meas tran vdout1_16ck6 FIND v(dout1_16) AT=35.025n

* CHECK dout1_17 Vdout1_17ck6 = 0.9 time = 35
.meas tran vdout1_17ck6 FIND v(dout1_17) AT=35.025n

* CHECK dout1_18 Vdout1_18ck6 = 0.9 time = 35
.meas tran vdout1_18ck6 FIND v(dout1_18) AT=35.025n

* CHECK dout1_19 Vdout1_19ck6 = 0.9 time = 35
.meas tran vdout1_19ck6 FIND v(dout1_19) AT=35.025n

* CHECK dout1_20 Vdout1_20ck6 = 0.9 time = 35
.meas tran vdout1_20ck6 FIND v(dout1_20) AT=35.025n

* CHECK dout1_21 Vdout1_21ck6 = 0 time = 35
.meas tran vdout1_21ck6 FIND v(dout1_21) AT=35.025n

* CHECK dout1_22 Vdout1_22ck6 = 0 time = 35
.meas tran vdout1_22ck6 FIND v(dout1_22) AT=35.025n

* CHECK dout1_23 Vdout1_23ck6 = 0 time = 35
.meas tran vdout1_23ck6 FIND v(dout1_23) AT=35.025n

* CHECK dout1_24 Vdout1_24ck6 = 0 time = 35
.meas tran vdout1_24ck6 FIND v(dout1_24) AT=35.025n

* CHECK dout1_25 Vdout1_25ck6 = 0 time = 35
.meas tran vdout1_25ck6 FIND v(dout1_25) AT=35.025n

* CHECK dout1_26 Vdout1_26ck6 = 0 time = 35
.meas tran vdout1_26ck6 FIND v(dout1_26) AT=35.025n

* CHECK dout1_27 Vdout1_27ck6 = 0.9 time = 35
.meas tran vdout1_27ck6 FIND v(dout1_27) AT=35.025n

* CHECK dout1_28 Vdout1_28ck6 = 0 time = 35
.meas tran vdout1_28ck6 FIND v(dout1_28) AT=35.025n

* CHECK dout1_29 Vdout1_29ck6 = 0 time = 35
.meas tran vdout1_29ck6 FIND v(dout1_29) AT=35.025n

* CHECK dout1_30 Vdout1_30ck6 = 0.9 time = 35
.meas tran vdout1_30ck6 FIND v(dout1_30) AT=35.025n

* CHECK dout1_31 Vdout1_31ck6 = 0.9 time = 35
.meas tran vdout1_31ck6 FIND v(dout1_31) AT=35.025n

* CHECK dout1_32 Vdout1_32ck6 = 0.9 time = 35
.meas tran vdout1_32ck6 FIND v(dout1_32) AT=35.025n

* CHECK dout1_33 Vdout1_33ck6 = 0 time = 35
.meas tran vdout1_33ck6 FIND v(dout1_33) AT=35.025n

* CHECK dout1_34 Vdout1_34ck6 = 0.9 time = 35
.meas tran vdout1_34ck6 FIND v(dout1_34) AT=35.025n

* CHECK dout1_35 Vdout1_35ck6 = 0 time = 35
.meas tran vdout1_35ck6 FIND v(dout1_35) AT=35.025n

* CHECK dout1_36 Vdout1_36ck6 = 0.9 time = 35
.meas tran vdout1_36ck6 FIND v(dout1_36) AT=35.025n

* CHECK dout1_37 Vdout1_37ck6 = 0 time = 35
.meas tran vdout1_37ck6 FIND v(dout1_37) AT=35.025n

* CHECK dout1_38 Vdout1_38ck6 = 0 time = 35
.meas tran vdout1_38ck6 FIND v(dout1_38) AT=35.025n

* CHECK dout1_39 Vdout1_39ck6 = 0.9 time = 35
.meas tran vdout1_39ck6 FIND v(dout1_39) AT=35.025n

* CHECK dout1_40 Vdout1_40ck6 = 0 time = 35
.meas tran vdout1_40ck6 FIND v(dout1_40) AT=35.025n

* CHECK dout1_41 Vdout1_41ck6 = 0 time = 35
.meas tran vdout1_41ck6 FIND v(dout1_41) AT=35.025n

* CHECK dout1_42 Vdout1_42ck6 = 0.9 time = 35
.meas tran vdout1_42ck6 FIND v(dout1_42) AT=35.025n

* CHECK dout1_43 Vdout1_43ck6 = 0 time = 35
.meas tran vdout1_43ck6 FIND v(dout1_43) AT=35.025n

* CHECK dout1_44 Vdout1_44ck6 = 0 time = 35
.meas tran vdout1_44ck6 FIND v(dout1_44) AT=35.025n

* CHECK dout1_45 Vdout1_45ck6 = 0 time = 35
.meas tran vdout1_45ck6 FIND v(dout1_45) AT=35.025n

* CHECK dout1_46 Vdout1_46ck6 = 0.9 time = 35
.meas tran vdout1_46ck6 FIND v(dout1_46) AT=35.025n

* CHECK dout1_47 Vdout1_47ck6 = 0 time = 35
.meas tran vdout1_47ck6 FIND v(dout1_47) AT=35.025n

* CHECK dout1_48 Vdout1_48ck6 = 0.9 time = 35
.meas tran vdout1_48ck6 FIND v(dout1_48) AT=35.025n

* CHECK dout1_49 Vdout1_49ck6 = 0 time = 35
.meas tran vdout1_49ck6 FIND v(dout1_49) AT=35.025n

* CHECK dout1_50 Vdout1_50ck6 = 0 time = 35
.meas tran vdout1_50ck6 FIND v(dout1_50) AT=35.025n

* CHECK dout1_51 Vdout1_51ck6 = 0.9 time = 35
.meas tran vdout1_51ck6 FIND v(dout1_51) AT=35.025n

* CHECK dout1_52 Vdout1_52ck6 = 0.9 time = 35
.meas tran vdout1_52ck6 FIND v(dout1_52) AT=35.025n

* CHECK dout1_53 Vdout1_53ck6 = 0 time = 35
.meas tran vdout1_53ck6 FIND v(dout1_53) AT=35.025n

* CHECK dout1_54 Vdout1_54ck6 = 0 time = 35
.meas tran vdout1_54ck6 FIND v(dout1_54) AT=35.025n

* CHECK dout1_55 Vdout1_55ck6 = 0 time = 35
.meas tran vdout1_55ck6 FIND v(dout1_55) AT=35.025n

* CHECK dout1_56 Vdout1_56ck6 = 0 time = 35
.meas tran vdout1_56ck6 FIND v(dout1_56) AT=35.025n

* CHECK dout1_57 Vdout1_57ck6 = 0.9 time = 35
.meas tran vdout1_57ck6 FIND v(dout1_57) AT=35.025n

* CHECK dout1_58 Vdout1_58ck6 = 0 time = 35
.meas tran vdout1_58ck6 FIND v(dout1_58) AT=35.025n

* CHECK dout1_59 Vdout1_59ck6 = 0 time = 35
.meas tran vdout1_59ck6 FIND v(dout1_59) AT=35.025n

* CHECK dout1_60 Vdout1_60ck6 = 0.9 time = 35
.meas tran vdout1_60ck6 FIND v(dout1_60) AT=35.025n

* CHECK dout1_61 Vdout1_61ck6 = 0.9 time = 35
.meas tran vdout1_61ck6 FIND v(dout1_61) AT=35.025n

* CHECK dout1_62 Vdout1_62ck6 = 0 time = 35
.meas tran vdout1_62ck6 FIND v(dout1_62) AT=35.025n

* CHECK dout1_63 Vdout1_63ck6 = 0.9 time = 35
.meas tran vdout1_63ck6 FIND v(dout1_63) AT=35.025n

* CHECK dout1_64 Vdout1_64ck6 = 0.9 time = 35
.meas tran vdout1_64ck6 FIND v(dout1_64) AT=35.025n

* CHECK dout1_65 Vdout1_65ck6 = 0 time = 35
.meas tran vdout1_65ck6 FIND v(dout1_65) AT=35.025n

* CHECK dout1_66 Vdout1_66ck6 = 0.9 time = 35
.meas tran vdout1_66ck6 FIND v(dout1_66) AT=35.025n

* CHECK dout1_67 Vdout1_67ck6 = 0.9 time = 35
.meas tran vdout1_67ck6 FIND v(dout1_67) AT=35.025n

* CHECK dout1_68 Vdout1_68ck6 = 0.9 time = 35
.meas tran vdout1_68ck6 FIND v(dout1_68) AT=35.025n

* CHECK dout1_69 Vdout1_69ck6 = 0.9 time = 35
.meas tran vdout1_69ck6 FIND v(dout1_69) AT=35.025n

* CHECK dout1_70 Vdout1_70ck6 = 0 time = 35
.meas tran vdout1_70ck6 FIND v(dout1_70) AT=35.025n

* CHECK dout1_71 Vdout1_71ck6 = 0.9 time = 35
.meas tran vdout1_71ck6 FIND v(dout1_71) AT=35.025n

* CHECK dout1_72 Vdout1_72ck6 = 0 time = 35
.meas tran vdout1_72ck6 FIND v(dout1_72) AT=35.025n

* CHECK dout1_73 Vdout1_73ck6 = 0 time = 35
.meas tran vdout1_73ck6 FIND v(dout1_73) AT=35.025n

* CHECK dout1_74 Vdout1_74ck6 = 0.9 time = 35
.meas tran vdout1_74ck6 FIND v(dout1_74) AT=35.025n

* CHECK dout1_75 Vdout1_75ck6 = 0.9 time = 35
.meas tran vdout1_75ck6 FIND v(dout1_75) AT=35.025n

* CHECK dout1_76 Vdout1_76ck6 = 0.9 time = 35
.meas tran vdout1_76ck6 FIND v(dout1_76) AT=35.025n

* CHECK dout1_77 Vdout1_77ck6 = 0 time = 35
.meas tran vdout1_77ck6 FIND v(dout1_77) AT=35.025n

* CHECK dout1_78 Vdout1_78ck6 = 0.9 time = 35
.meas tran vdout1_78ck6 FIND v(dout1_78) AT=35.025n

* CHECK dout1_79 Vdout1_79ck6 = 0.9 time = 35
.meas tran vdout1_79ck6 FIND v(dout1_79) AT=35.025n

* CHECK dout1_80 Vdout1_80ck6 = 0 time = 35
.meas tran vdout1_80ck6 FIND v(dout1_80) AT=35.025n

* CHECK dout1_81 Vdout1_81ck6 = 0.9 time = 35
.meas tran vdout1_81ck6 FIND v(dout1_81) AT=35.025n

* CHECK dout1_82 Vdout1_82ck6 = 0 time = 35
.meas tran vdout1_82ck6 FIND v(dout1_82) AT=35.025n

* CHECK dout1_83 Vdout1_83ck6 = 0.9 time = 35
.meas tran vdout1_83ck6 FIND v(dout1_83) AT=35.025n

* CHECK dout1_84 Vdout1_84ck6 = 0.9 time = 35
.meas tran vdout1_84ck6 FIND v(dout1_84) AT=35.025n

* CHECK dout1_85 Vdout1_85ck6 = 0.9 time = 35
.meas tran vdout1_85ck6 FIND v(dout1_85) AT=35.025n

* CHECK dout1_86 Vdout1_86ck6 = 0 time = 35
.meas tran vdout1_86ck6 FIND v(dout1_86) AT=35.025n

* CHECK dout1_87 Vdout1_87ck6 = 0.9 time = 35
.meas tran vdout1_87ck6 FIND v(dout1_87) AT=35.025n

* CHECK dout1_88 Vdout1_88ck6 = 0.9 time = 35
.meas tran vdout1_88ck6 FIND v(dout1_88) AT=35.025n

* CHECK dout1_89 Vdout1_89ck6 = 0 time = 35
.meas tran vdout1_89ck6 FIND v(dout1_89) AT=35.025n

* CHECK dout1_90 Vdout1_90ck6 = 0 time = 35
.meas tran vdout1_90ck6 FIND v(dout1_90) AT=35.025n

* CHECK dout1_91 Vdout1_91ck6 = 0 time = 35
.meas tran vdout1_91ck6 FIND v(dout1_91) AT=35.025n

* CHECK dout1_92 Vdout1_92ck6 = 0 time = 35
.meas tran vdout1_92ck6 FIND v(dout1_92) AT=35.025n

* CHECK dout1_93 Vdout1_93ck6 = 0 time = 35
.meas tran vdout1_93ck6 FIND v(dout1_93) AT=35.025n

* CHECK dout1_94 Vdout1_94ck6 = 0.9 time = 35
.meas tran vdout1_94ck6 FIND v(dout1_94) AT=35.025n

* CHECK dout1_95 Vdout1_95ck6 = 0.9 time = 35
.meas tran vdout1_95ck6 FIND v(dout1_95) AT=35.025n

* CHECK dout1_96 Vdout1_96ck6 = 0 time = 35
.meas tran vdout1_96ck6 FIND v(dout1_96) AT=35.025n

* CHECK dout1_97 Vdout1_97ck6 = 0 time = 35
.meas tran vdout1_97ck6 FIND v(dout1_97) AT=35.025n

* CHECK dout1_98 Vdout1_98ck6 = 0 time = 35
.meas tran vdout1_98ck6 FIND v(dout1_98) AT=35.025n

* CHECK dout1_99 Vdout1_99ck6 = 0 time = 35
.meas tran vdout1_99ck6 FIND v(dout1_99) AT=35.025n

* CHECK dout1_100 Vdout1_100ck6 = 0 time = 35
.meas tran vdout1_100ck6 FIND v(dout1_100) AT=35.025n

* CHECK dout1_101 Vdout1_101ck6 = 0.9 time = 35
.meas tran vdout1_101ck6 FIND v(dout1_101) AT=35.025n

* CHECK dout1_102 Vdout1_102ck6 = 0.9 time = 35
.meas tran vdout1_102ck6 FIND v(dout1_102) AT=35.025n

* CHECK dout1_103 Vdout1_103ck6 = 0.9 time = 35
.meas tran vdout1_103ck6 FIND v(dout1_103) AT=35.025n

* CHECK dout1_104 Vdout1_104ck6 = 0.9 time = 35
.meas tran vdout1_104ck6 FIND v(dout1_104) AT=35.025n

* CHECK dout1_105 Vdout1_105ck6 = 0 time = 35
.meas tran vdout1_105ck6 FIND v(dout1_105) AT=35.025n

* CHECK dout1_106 Vdout1_106ck6 = 0 time = 35
.meas tran vdout1_106ck6 FIND v(dout1_106) AT=35.025n

* CHECK dout1_107 Vdout1_107ck6 = 0.9 time = 35
.meas tran vdout1_107ck6 FIND v(dout1_107) AT=35.025n

* CHECK dout1_108 Vdout1_108ck6 = 0 time = 35
.meas tran vdout1_108ck6 FIND v(dout1_108) AT=35.025n

* CHECK dout1_109 Vdout1_109ck6 = 0 time = 35
.meas tran vdout1_109ck6 FIND v(dout1_109) AT=35.025n

* CHECK dout1_110 Vdout1_110ck6 = 0.9 time = 35
.meas tran vdout1_110ck6 FIND v(dout1_110) AT=35.025n

* CHECK dout1_111 Vdout1_111ck6 = 0 time = 35
.meas tran vdout1_111ck6 FIND v(dout1_111) AT=35.025n

* CHECK dout1_112 Vdout1_112ck6 = 0 time = 35
.meas tran vdout1_112ck6 FIND v(dout1_112) AT=35.025n

* CHECK dout1_113 Vdout1_113ck6 = 0 time = 35
.meas tran vdout1_113ck6 FIND v(dout1_113) AT=35.025n

* CHECK dout1_114 Vdout1_114ck6 = 0 time = 35
.meas tran vdout1_114ck6 FIND v(dout1_114) AT=35.025n

* CHECK dout1_115 Vdout1_115ck6 = 0.9 time = 35
.meas tran vdout1_115ck6 FIND v(dout1_115) AT=35.025n

* CHECK dout1_116 Vdout1_116ck6 = 0.9 time = 35
.meas tran vdout1_116ck6 FIND v(dout1_116) AT=35.025n

* CHECK dout1_117 Vdout1_117ck6 = 0.9 time = 35
.meas tran vdout1_117ck6 FIND v(dout1_117) AT=35.025n

* CHECK dout1_118 Vdout1_118ck6 = 0.9 time = 35
.meas tran vdout1_118ck6 FIND v(dout1_118) AT=35.025n

* CHECK dout1_119 Vdout1_119ck6 = 0.9 time = 35
.meas tran vdout1_119ck6 FIND v(dout1_119) AT=35.025n

* CHECK dout1_0 Vdout1_0ck14 = 0.9 time = 75
.meas tran vdout1_0ck14 FIND v(dout1_0) AT=75.025n

* CHECK dout1_1 Vdout1_1ck14 = 0.9 time = 75
.meas tran vdout1_1ck14 FIND v(dout1_1) AT=75.025n

* CHECK dout1_2 Vdout1_2ck14 = 0 time = 75
.meas tran vdout1_2ck14 FIND v(dout1_2) AT=75.025n

* CHECK dout1_3 Vdout1_3ck14 = 0.9 time = 75
.meas tran vdout1_3ck14 FIND v(dout1_3) AT=75.025n

* CHECK dout1_4 Vdout1_4ck14 = 0 time = 75
.meas tran vdout1_4ck14 FIND v(dout1_4) AT=75.025n

* CHECK dout1_5 Vdout1_5ck14 = 0 time = 75
.meas tran vdout1_5ck14 FIND v(dout1_5) AT=75.025n

* CHECK dout1_6 Vdout1_6ck14 = 0.9 time = 75
.meas tran vdout1_6ck14 FIND v(dout1_6) AT=75.025n

* CHECK dout1_7 Vdout1_7ck14 = 0.9 time = 75
.meas tran vdout1_7ck14 FIND v(dout1_7) AT=75.025n

* CHECK dout1_8 Vdout1_8ck14 = 0 time = 75
.meas tran vdout1_8ck14 FIND v(dout1_8) AT=75.025n

* CHECK dout1_9 Vdout1_9ck14 = 0.9 time = 75
.meas tran vdout1_9ck14 FIND v(dout1_9) AT=75.025n

* CHECK dout1_10 Vdout1_10ck14 = 0.9 time = 75
.meas tran vdout1_10ck14 FIND v(dout1_10) AT=75.025n

* CHECK dout1_11 Vdout1_11ck14 = 0.9 time = 75
.meas tran vdout1_11ck14 FIND v(dout1_11) AT=75.025n

* CHECK dout1_12 Vdout1_12ck14 = 0.9 time = 75
.meas tran vdout1_12ck14 FIND v(dout1_12) AT=75.025n

* CHECK dout1_13 Vdout1_13ck14 = 0.9 time = 75
.meas tran vdout1_13ck14 FIND v(dout1_13) AT=75.025n

* CHECK dout1_14 Vdout1_14ck14 = 0 time = 75
.meas tran vdout1_14ck14 FIND v(dout1_14) AT=75.025n

* CHECK dout1_15 Vdout1_15ck14 = 0 time = 75
.meas tran vdout1_15ck14 FIND v(dout1_15) AT=75.025n

* CHECK dout1_16 Vdout1_16ck14 = 0.9 time = 75
.meas tran vdout1_16ck14 FIND v(dout1_16) AT=75.025n

* CHECK dout1_17 Vdout1_17ck14 = 0.9 time = 75
.meas tran vdout1_17ck14 FIND v(dout1_17) AT=75.025n

* CHECK dout1_18 Vdout1_18ck14 = 0.9 time = 75
.meas tran vdout1_18ck14 FIND v(dout1_18) AT=75.025n

* CHECK dout1_19 Vdout1_19ck14 = 0.9 time = 75
.meas tran vdout1_19ck14 FIND v(dout1_19) AT=75.025n

* CHECK dout1_20 Vdout1_20ck14 = 0.9 time = 75
.meas tran vdout1_20ck14 FIND v(dout1_20) AT=75.025n

* CHECK dout1_21 Vdout1_21ck14 = 0 time = 75
.meas tran vdout1_21ck14 FIND v(dout1_21) AT=75.025n

* CHECK dout1_22 Vdout1_22ck14 = 0 time = 75
.meas tran vdout1_22ck14 FIND v(dout1_22) AT=75.025n

* CHECK dout1_23 Vdout1_23ck14 = 0 time = 75
.meas tran vdout1_23ck14 FIND v(dout1_23) AT=75.025n

* CHECK dout1_24 Vdout1_24ck14 = 0 time = 75
.meas tran vdout1_24ck14 FIND v(dout1_24) AT=75.025n

* CHECK dout1_25 Vdout1_25ck14 = 0 time = 75
.meas tran vdout1_25ck14 FIND v(dout1_25) AT=75.025n

* CHECK dout1_26 Vdout1_26ck14 = 0 time = 75
.meas tran vdout1_26ck14 FIND v(dout1_26) AT=75.025n

* CHECK dout1_27 Vdout1_27ck14 = 0.9 time = 75
.meas tran vdout1_27ck14 FIND v(dout1_27) AT=75.025n

* CHECK dout1_28 Vdout1_28ck14 = 0 time = 75
.meas tran vdout1_28ck14 FIND v(dout1_28) AT=75.025n

* CHECK dout1_29 Vdout1_29ck14 = 0 time = 75
.meas tran vdout1_29ck14 FIND v(dout1_29) AT=75.025n

* CHECK dout1_30 Vdout1_30ck14 = 0.9 time = 75
.meas tran vdout1_30ck14 FIND v(dout1_30) AT=75.025n

* CHECK dout1_31 Vdout1_31ck14 = 0 time = 75
.meas tran vdout1_31ck14 FIND v(dout1_31) AT=75.025n

* CHECK dout1_32 Vdout1_32ck14 = 0 time = 75
.meas tran vdout1_32ck14 FIND v(dout1_32) AT=75.025n

* CHECK dout1_33 Vdout1_33ck14 = 0 time = 75
.meas tran vdout1_33ck14 FIND v(dout1_33) AT=75.025n

* CHECK dout1_34 Vdout1_34ck14 = 0.9 time = 75
.meas tran vdout1_34ck14 FIND v(dout1_34) AT=75.025n

* CHECK dout1_35 Vdout1_35ck14 = 0 time = 75
.meas tran vdout1_35ck14 FIND v(dout1_35) AT=75.025n

* CHECK dout1_36 Vdout1_36ck14 = 0 time = 75
.meas tran vdout1_36ck14 FIND v(dout1_36) AT=75.025n

* CHECK dout1_37 Vdout1_37ck14 = 0 time = 75
.meas tran vdout1_37ck14 FIND v(dout1_37) AT=75.025n

* CHECK dout1_38 Vdout1_38ck14 = 0.9 time = 75
.meas tran vdout1_38ck14 FIND v(dout1_38) AT=75.025n

* CHECK dout1_39 Vdout1_39ck14 = 0 time = 75
.meas tran vdout1_39ck14 FIND v(dout1_39) AT=75.025n

* CHECK dout1_40 Vdout1_40ck14 = 0 time = 75
.meas tran vdout1_40ck14 FIND v(dout1_40) AT=75.025n

* CHECK dout1_41 Vdout1_41ck14 = 0 time = 75
.meas tran vdout1_41ck14 FIND v(dout1_41) AT=75.025n

* CHECK dout1_42 Vdout1_42ck14 = 0 time = 75
.meas tran vdout1_42ck14 FIND v(dout1_42) AT=75.025n

* CHECK dout1_43 Vdout1_43ck14 = 0 time = 75
.meas tran vdout1_43ck14 FIND v(dout1_43) AT=75.025n

* CHECK dout1_44 Vdout1_44ck14 = 0 time = 75
.meas tran vdout1_44ck14 FIND v(dout1_44) AT=75.025n

* CHECK dout1_45 Vdout1_45ck14 = 0.9 time = 75
.meas tran vdout1_45ck14 FIND v(dout1_45) AT=75.025n

* CHECK dout1_46 Vdout1_46ck14 = 0.9 time = 75
.meas tran vdout1_46ck14 FIND v(dout1_46) AT=75.025n

* CHECK dout1_47 Vdout1_47ck14 = 0 time = 75
.meas tran vdout1_47ck14 FIND v(dout1_47) AT=75.025n

* CHECK dout1_48 Vdout1_48ck14 = 0 time = 75
.meas tran vdout1_48ck14 FIND v(dout1_48) AT=75.025n

* CHECK dout1_49 Vdout1_49ck14 = 0 time = 75
.meas tran vdout1_49ck14 FIND v(dout1_49) AT=75.025n

* CHECK dout1_50 Vdout1_50ck14 = 0.9 time = 75
.meas tran vdout1_50ck14 FIND v(dout1_50) AT=75.025n

* CHECK dout1_51 Vdout1_51ck14 = 0 time = 75
.meas tran vdout1_51ck14 FIND v(dout1_51) AT=75.025n

* CHECK dout1_52 Vdout1_52ck14 = 0 time = 75
.meas tran vdout1_52ck14 FIND v(dout1_52) AT=75.025n

* CHECK dout1_53 Vdout1_53ck14 = 0.9 time = 75
.meas tran vdout1_53ck14 FIND v(dout1_53) AT=75.025n

* CHECK dout1_54 Vdout1_54ck14 = 0.9 time = 75
.meas tran vdout1_54ck14 FIND v(dout1_54) AT=75.025n

* CHECK dout1_55 Vdout1_55ck14 = 0.9 time = 75
.meas tran vdout1_55ck14 FIND v(dout1_55) AT=75.025n

* CHECK dout1_56 Vdout1_56ck14 = 0.9 time = 75
.meas tran vdout1_56ck14 FIND v(dout1_56) AT=75.025n

* CHECK dout1_57 Vdout1_57ck14 = 0 time = 75
.meas tran vdout1_57ck14 FIND v(dout1_57) AT=75.025n

* CHECK dout1_58 Vdout1_58ck14 = 0 time = 75
.meas tran vdout1_58ck14 FIND v(dout1_58) AT=75.025n

* CHECK dout1_59 Vdout1_59ck14 = 0.9 time = 75
.meas tran vdout1_59ck14 FIND v(dout1_59) AT=75.025n

* CHECK dout1_60 Vdout1_60ck14 = 0.9 time = 75
.meas tran vdout1_60ck14 FIND v(dout1_60) AT=75.025n

* CHECK dout1_61 Vdout1_61ck14 = 0.9 time = 75
.meas tran vdout1_61ck14 FIND v(dout1_61) AT=75.025n

* CHECK dout1_62 Vdout1_62ck14 = 0 time = 75
.meas tran vdout1_62ck14 FIND v(dout1_62) AT=75.025n

* CHECK dout1_63 Vdout1_63ck14 = 0 time = 75
.meas tran vdout1_63ck14 FIND v(dout1_63) AT=75.025n

* CHECK dout1_64 Vdout1_64ck14 = 0.9 time = 75
.meas tran vdout1_64ck14 FIND v(dout1_64) AT=75.025n

* CHECK dout1_65 Vdout1_65ck14 = 0.9 time = 75
.meas tran vdout1_65ck14 FIND v(dout1_65) AT=75.025n

* CHECK dout1_66 Vdout1_66ck14 = 0 time = 75
.meas tran vdout1_66ck14 FIND v(dout1_66) AT=75.025n

* CHECK dout1_67 Vdout1_67ck14 = 0.9 time = 75
.meas tran vdout1_67ck14 FIND v(dout1_67) AT=75.025n

* CHECK dout1_68 Vdout1_68ck14 = 0.9 time = 75
.meas tran vdout1_68ck14 FIND v(dout1_68) AT=75.025n

* CHECK dout1_69 Vdout1_69ck14 = 0 time = 75
.meas tran vdout1_69ck14 FIND v(dout1_69) AT=75.025n

* CHECK dout1_70 Vdout1_70ck14 = 0 time = 75
.meas tran vdout1_70ck14 FIND v(dout1_70) AT=75.025n

* CHECK dout1_71 Vdout1_71ck14 = 0.9 time = 75
.meas tran vdout1_71ck14 FIND v(dout1_71) AT=75.025n

* CHECK dout1_72 Vdout1_72ck14 = 0 time = 75
.meas tran vdout1_72ck14 FIND v(dout1_72) AT=75.025n

* CHECK dout1_73 Vdout1_73ck14 = 0 time = 75
.meas tran vdout1_73ck14 FIND v(dout1_73) AT=75.025n

* CHECK dout1_74 Vdout1_74ck14 = 0 time = 75
.meas tran vdout1_74ck14 FIND v(dout1_74) AT=75.025n

* CHECK dout1_75 Vdout1_75ck14 = 0 time = 75
.meas tran vdout1_75ck14 FIND v(dout1_75) AT=75.025n

* CHECK dout1_76 Vdout1_76ck14 = 0.9 time = 75
.meas tran vdout1_76ck14 FIND v(dout1_76) AT=75.025n

* CHECK dout1_77 Vdout1_77ck14 = 0 time = 75
.meas tran vdout1_77ck14 FIND v(dout1_77) AT=75.025n

* CHECK dout1_78 Vdout1_78ck14 = 0.9 time = 75
.meas tran vdout1_78ck14 FIND v(dout1_78) AT=75.025n

* CHECK dout1_79 Vdout1_79ck14 = 0 time = 75
.meas tran vdout1_79ck14 FIND v(dout1_79) AT=75.025n

* CHECK dout1_80 Vdout1_80ck14 = 0 time = 75
.meas tran vdout1_80ck14 FIND v(dout1_80) AT=75.025n

* CHECK dout1_81 Vdout1_81ck14 = 0 time = 75
.meas tran vdout1_81ck14 FIND v(dout1_81) AT=75.025n

* CHECK dout1_82 Vdout1_82ck14 = 0 time = 75
.meas tran vdout1_82ck14 FIND v(dout1_82) AT=75.025n

* CHECK dout1_83 Vdout1_83ck14 = 0.9 time = 75
.meas tran vdout1_83ck14 FIND v(dout1_83) AT=75.025n

* CHECK dout1_84 Vdout1_84ck14 = 0 time = 75
.meas tran vdout1_84ck14 FIND v(dout1_84) AT=75.025n

* CHECK dout1_85 Vdout1_85ck14 = 0.9 time = 75
.meas tran vdout1_85ck14 FIND v(dout1_85) AT=75.025n

* CHECK dout1_86 Vdout1_86ck14 = 0 time = 75
.meas tran vdout1_86ck14 FIND v(dout1_86) AT=75.025n

* CHECK dout1_87 Vdout1_87ck14 = 0 time = 75
.meas tran vdout1_87ck14 FIND v(dout1_87) AT=75.025n

* CHECK dout1_88 Vdout1_88ck14 = 0.9 time = 75
.meas tran vdout1_88ck14 FIND v(dout1_88) AT=75.025n

* CHECK dout1_89 Vdout1_89ck14 = 0.9 time = 75
.meas tran vdout1_89ck14 FIND v(dout1_89) AT=75.025n

* CHECK dout1_90 Vdout1_90ck14 = 0 time = 75
.meas tran vdout1_90ck14 FIND v(dout1_90) AT=75.025n

* CHECK dout1_91 Vdout1_91ck14 = 0 time = 75
.meas tran vdout1_91ck14 FIND v(dout1_91) AT=75.025n

* CHECK dout1_92 Vdout1_92ck14 = 0 time = 75
.meas tran vdout1_92ck14 FIND v(dout1_92) AT=75.025n

* CHECK dout1_93 Vdout1_93ck14 = 0 time = 75
.meas tran vdout1_93ck14 FIND v(dout1_93) AT=75.025n

* CHECK dout1_94 Vdout1_94ck14 = 0.9 time = 75
.meas tran vdout1_94ck14 FIND v(dout1_94) AT=75.025n

* CHECK dout1_95 Vdout1_95ck14 = 0.9 time = 75
.meas tran vdout1_95ck14 FIND v(dout1_95) AT=75.025n

* CHECK dout1_96 Vdout1_96ck14 = 0 time = 75
.meas tran vdout1_96ck14 FIND v(dout1_96) AT=75.025n

* CHECK dout1_97 Vdout1_97ck14 = 0 time = 75
.meas tran vdout1_97ck14 FIND v(dout1_97) AT=75.025n

* CHECK dout1_98 Vdout1_98ck14 = 0 time = 75
.meas tran vdout1_98ck14 FIND v(dout1_98) AT=75.025n

* CHECK dout1_99 Vdout1_99ck14 = 0 time = 75
.meas tran vdout1_99ck14 FIND v(dout1_99) AT=75.025n

* CHECK dout1_100 Vdout1_100ck14 = 0 time = 75
.meas tran vdout1_100ck14 FIND v(dout1_100) AT=75.025n

* CHECK dout1_101 Vdout1_101ck14 = 0.9 time = 75
.meas tran vdout1_101ck14 FIND v(dout1_101) AT=75.025n

* CHECK dout1_102 Vdout1_102ck14 = 0.9 time = 75
.meas tran vdout1_102ck14 FIND v(dout1_102) AT=75.025n

* CHECK dout1_103 Vdout1_103ck14 = 0.9 time = 75
.meas tran vdout1_103ck14 FIND v(dout1_103) AT=75.025n

* CHECK dout1_104 Vdout1_104ck14 = 0.9 time = 75
.meas tran vdout1_104ck14 FIND v(dout1_104) AT=75.025n

* CHECK dout1_105 Vdout1_105ck14 = 0 time = 75
.meas tran vdout1_105ck14 FIND v(dout1_105) AT=75.025n

* CHECK dout1_106 Vdout1_106ck14 = 0 time = 75
.meas tran vdout1_106ck14 FIND v(dout1_106) AT=75.025n

* CHECK dout1_107 Vdout1_107ck14 = 0.9 time = 75
.meas tran vdout1_107ck14 FIND v(dout1_107) AT=75.025n

* CHECK dout1_108 Vdout1_108ck14 = 0 time = 75
.meas tran vdout1_108ck14 FIND v(dout1_108) AT=75.025n

* CHECK dout1_109 Vdout1_109ck14 = 0 time = 75
.meas tran vdout1_109ck14 FIND v(dout1_109) AT=75.025n

* CHECK dout1_110 Vdout1_110ck14 = 0.9 time = 75
.meas tran vdout1_110ck14 FIND v(dout1_110) AT=75.025n

* CHECK dout1_111 Vdout1_111ck14 = 0 time = 75
.meas tran vdout1_111ck14 FIND v(dout1_111) AT=75.025n

* CHECK dout1_112 Vdout1_112ck14 = 0 time = 75
.meas tran vdout1_112ck14 FIND v(dout1_112) AT=75.025n

* CHECK dout1_113 Vdout1_113ck14 = 0 time = 75
.meas tran vdout1_113ck14 FIND v(dout1_113) AT=75.025n

* CHECK dout1_114 Vdout1_114ck14 = 0 time = 75
.meas tran vdout1_114ck14 FIND v(dout1_114) AT=75.025n

* CHECK dout1_115 Vdout1_115ck14 = 0.9 time = 75
.meas tran vdout1_115ck14 FIND v(dout1_115) AT=75.025n

* CHECK dout1_116 Vdout1_116ck14 = 0.9 time = 75
.meas tran vdout1_116ck14 FIND v(dout1_116) AT=75.025n

* CHECK dout1_117 Vdout1_117ck14 = 0.9 time = 75
.meas tran vdout1_117ck14 FIND v(dout1_117) AT=75.025n

* CHECK dout1_118 Vdout1_118ck14 = 0.9 time = 75
.meas tran vdout1_118ck14 FIND v(dout1_118) AT=75.025n

* CHECK dout1_119 Vdout1_119ck14 = 0.9 time = 75
.meas tran vdout1_119ck14 FIND v(dout1_119) AT=75.025n

* CHECK dout1_0 Vdout1_0ck18 = 0 time = 95
.meas tran vdout1_0ck18 FIND v(dout1_0) AT=95.025n

* CHECK dout1_1 Vdout1_1ck18 = 0.9 time = 95
.meas tran vdout1_1ck18 FIND v(dout1_1) AT=95.025n

* CHECK dout1_2 Vdout1_2ck18 = 0.9 time = 95
.meas tran vdout1_2ck18 FIND v(dout1_2) AT=95.025n

* CHECK dout1_3 Vdout1_3ck18 = 0.9 time = 95
.meas tran vdout1_3ck18 FIND v(dout1_3) AT=95.025n

* CHECK dout1_4 Vdout1_4ck18 = 0 time = 95
.meas tran vdout1_4ck18 FIND v(dout1_4) AT=95.025n

* CHECK dout1_5 Vdout1_5ck18 = 0 time = 95
.meas tran vdout1_5ck18 FIND v(dout1_5) AT=95.025n

* CHECK dout1_6 Vdout1_6ck18 = 0 time = 95
.meas tran vdout1_6ck18 FIND v(dout1_6) AT=95.025n

* CHECK dout1_7 Vdout1_7ck18 = 0.9 time = 95
.meas tran vdout1_7ck18 FIND v(dout1_7) AT=95.025n

* CHECK dout1_8 Vdout1_8ck18 = 0 time = 95
.meas tran vdout1_8ck18 FIND v(dout1_8) AT=95.025n

* CHECK dout1_9 Vdout1_9ck18 = 0.9 time = 95
.meas tran vdout1_9ck18 FIND v(dout1_9) AT=95.025n

* CHECK dout1_10 Vdout1_10ck18 = 0 time = 95
.meas tran vdout1_10ck18 FIND v(dout1_10) AT=95.025n

* CHECK dout1_11 Vdout1_11ck18 = 0 time = 95
.meas tran vdout1_11ck18 FIND v(dout1_11) AT=95.025n

* CHECK dout1_12 Vdout1_12ck18 = 0 time = 95
.meas tran vdout1_12ck18 FIND v(dout1_12) AT=95.025n

* CHECK dout1_13 Vdout1_13ck18 = 0 time = 95
.meas tran vdout1_13ck18 FIND v(dout1_13) AT=95.025n

* CHECK dout1_14 Vdout1_14ck18 = 0.9 time = 95
.meas tran vdout1_14ck18 FIND v(dout1_14) AT=95.025n

* CHECK dout1_15 Vdout1_15ck18 = 0 time = 95
.meas tran vdout1_15ck18 FIND v(dout1_15) AT=95.025n

* CHECK dout1_16 Vdout1_16ck18 = 0 time = 95
.meas tran vdout1_16ck18 FIND v(dout1_16) AT=95.025n

* CHECK dout1_17 Vdout1_17ck18 = 0.9 time = 95
.meas tran vdout1_17ck18 FIND v(dout1_17) AT=95.025n

* CHECK dout1_18 Vdout1_18ck18 = 0 time = 95
.meas tran vdout1_18ck18 FIND v(dout1_18) AT=95.025n

* CHECK dout1_19 Vdout1_19ck18 = 0 time = 95
.meas tran vdout1_19ck18 FIND v(dout1_19) AT=95.025n

* CHECK dout1_20 Vdout1_20ck18 = 0 time = 95
.meas tran vdout1_20ck18 FIND v(dout1_20) AT=95.025n

* CHECK dout1_21 Vdout1_21ck18 = 0 time = 95
.meas tran vdout1_21ck18 FIND v(dout1_21) AT=95.025n

* CHECK dout1_22 Vdout1_22ck18 = 0 time = 95
.meas tran vdout1_22ck18 FIND v(dout1_22) AT=95.025n

* CHECK dout1_23 Vdout1_23ck18 = 0 time = 95
.meas tran vdout1_23ck18 FIND v(dout1_23) AT=95.025n

* CHECK dout1_24 Vdout1_24ck18 = 0 time = 95
.meas tran vdout1_24ck18 FIND v(dout1_24) AT=95.025n

* CHECK dout1_25 Vdout1_25ck18 = 0.9 time = 95
.meas tran vdout1_25ck18 FIND v(dout1_25) AT=95.025n

* CHECK dout1_26 Vdout1_26ck18 = 0 time = 95
.meas tran vdout1_26ck18 FIND v(dout1_26) AT=95.025n

* CHECK dout1_27 Vdout1_27ck18 = 0.9 time = 95
.meas tran vdout1_27ck18 FIND v(dout1_27) AT=95.025n

* CHECK dout1_28 Vdout1_28ck18 = 0.9 time = 95
.meas tran vdout1_28ck18 FIND v(dout1_28) AT=95.025n

* CHECK dout1_29 Vdout1_29ck18 = 0.9 time = 95
.meas tran vdout1_29ck18 FIND v(dout1_29) AT=95.025n

* CHECK dout1_30 Vdout1_30ck18 = 0 time = 95
.meas tran vdout1_30ck18 FIND v(dout1_30) AT=95.025n

* CHECK dout1_31 Vdout1_31ck18 = 0 time = 95
.meas tran vdout1_31ck18 FIND v(dout1_31) AT=95.025n

* CHECK dout1_32 Vdout1_32ck18 = 0 time = 95
.meas tran vdout1_32ck18 FIND v(dout1_32) AT=95.025n

* CHECK dout1_33 Vdout1_33ck18 = 0 time = 95
.meas tran vdout1_33ck18 FIND v(dout1_33) AT=95.025n

* CHECK dout1_34 Vdout1_34ck18 = 0.9 time = 95
.meas tran vdout1_34ck18 FIND v(dout1_34) AT=95.025n

* CHECK dout1_35 Vdout1_35ck18 = 0.9 time = 95
.meas tran vdout1_35ck18 FIND v(dout1_35) AT=95.025n

* CHECK dout1_36 Vdout1_36ck18 = 0.9 time = 95
.meas tran vdout1_36ck18 FIND v(dout1_36) AT=95.025n

* CHECK dout1_37 Vdout1_37ck18 = 0 time = 95
.meas tran vdout1_37ck18 FIND v(dout1_37) AT=95.025n

* CHECK dout1_38 Vdout1_38ck18 = 0.9 time = 95
.meas tran vdout1_38ck18 FIND v(dout1_38) AT=95.025n

* CHECK dout1_39 Vdout1_39ck18 = 0 time = 95
.meas tran vdout1_39ck18 FIND v(dout1_39) AT=95.025n

* CHECK dout1_40 Vdout1_40ck18 = 0 time = 95
.meas tran vdout1_40ck18 FIND v(dout1_40) AT=95.025n

* CHECK dout1_41 Vdout1_41ck18 = 0.9 time = 95
.meas tran vdout1_41ck18 FIND v(dout1_41) AT=95.025n

* CHECK dout1_42 Vdout1_42ck18 = 0 time = 95
.meas tran vdout1_42ck18 FIND v(dout1_42) AT=95.025n

* CHECK dout1_43 Vdout1_43ck18 = 0 time = 95
.meas tran vdout1_43ck18 FIND v(dout1_43) AT=95.025n

* CHECK dout1_44 Vdout1_44ck18 = 0 time = 95
.meas tran vdout1_44ck18 FIND v(dout1_44) AT=95.025n

* CHECK dout1_45 Vdout1_45ck18 = 0 time = 95
.meas tran vdout1_45ck18 FIND v(dout1_45) AT=95.025n

* CHECK dout1_46 Vdout1_46ck18 = 0 time = 95
.meas tran vdout1_46ck18 FIND v(dout1_46) AT=95.025n

* CHECK dout1_47 Vdout1_47ck18 = 0 time = 95
.meas tran vdout1_47ck18 FIND v(dout1_47) AT=95.025n

* CHECK dout1_48 Vdout1_48ck18 = 0 time = 95
.meas tran vdout1_48ck18 FIND v(dout1_48) AT=95.025n

* CHECK dout1_49 Vdout1_49ck18 = 0.9 time = 95
.meas tran vdout1_49ck18 FIND v(dout1_49) AT=95.025n

* CHECK dout1_50 Vdout1_50ck18 = 0 time = 95
.meas tran vdout1_50ck18 FIND v(dout1_50) AT=95.025n

* CHECK dout1_51 Vdout1_51ck18 = 0 time = 95
.meas tran vdout1_51ck18 FIND v(dout1_51) AT=95.025n

* CHECK dout1_52 Vdout1_52ck18 = 0 time = 95
.meas tran vdout1_52ck18 FIND v(dout1_52) AT=95.025n

* CHECK dout1_53 Vdout1_53ck18 = 0.9 time = 95
.meas tran vdout1_53ck18 FIND v(dout1_53) AT=95.025n

* CHECK dout1_54 Vdout1_54ck18 = 0.9 time = 95
.meas tran vdout1_54ck18 FIND v(dout1_54) AT=95.025n

* CHECK dout1_55 Vdout1_55ck18 = 0 time = 95
.meas tran vdout1_55ck18 FIND v(dout1_55) AT=95.025n

* CHECK dout1_56 Vdout1_56ck18 = 0.9 time = 95
.meas tran vdout1_56ck18 FIND v(dout1_56) AT=95.025n

* CHECK dout1_57 Vdout1_57ck18 = 0 time = 95
.meas tran vdout1_57ck18 FIND v(dout1_57) AT=95.025n

* CHECK dout1_58 Vdout1_58ck18 = 0.9 time = 95
.meas tran vdout1_58ck18 FIND v(dout1_58) AT=95.025n

* CHECK dout1_59 Vdout1_59ck18 = 0 time = 95
.meas tran vdout1_59ck18 FIND v(dout1_59) AT=95.025n

* CHECK dout1_60 Vdout1_60ck18 = 0.9 time = 95
.meas tran vdout1_60ck18 FIND v(dout1_60) AT=95.025n

* CHECK dout1_61 Vdout1_61ck18 = 0 time = 95
.meas tran vdout1_61ck18 FIND v(dout1_61) AT=95.025n

* CHECK dout1_62 Vdout1_62ck18 = 0 time = 95
.meas tran vdout1_62ck18 FIND v(dout1_62) AT=95.025n

* CHECK dout1_63 Vdout1_63ck18 = 0.9 time = 95
.meas tran vdout1_63ck18 FIND v(dout1_63) AT=95.025n

* CHECK dout1_64 Vdout1_64ck18 = 0.9 time = 95
.meas tran vdout1_64ck18 FIND v(dout1_64) AT=95.025n

* CHECK dout1_65 Vdout1_65ck18 = 0 time = 95
.meas tran vdout1_65ck18 FIND v(dout1_65) AT=95.025n

* CHECK dout1_66 Vdout1_66ck18 = 0.9 time = 95
.meas tran vdout1_66ck18 FIND v(dout1_66) AT=95.025n

* CHECK dout1_67 Vdout1_67ck18 = 0.9 time = 95
.meas tran vdout1_67ck18 FIND v(dout1_67) AT=95.025n

* CHECK dout1_68 Vdout1_68ck18 = 0 time = 95
.meas tran vdout1_68ck18 FIND v(dout1_68) AT=95.025n

* CHECK dout1_69 Vdout1_69ck18 = 0 time = 95
.meas tran vdout1_69ck18 FIND v(dout1_69) AT=95.025n

* CHECK dout1_70 Vdout1_70ck18 = 0 time = 95
.meas tran vdout1_70ck18 FIND v(dout1_70) AT=95.025n

* CHECK dout1_71 Vdout1_71ck18 = 0.9 time = 95
.meas tran vdout1_71ck18 FIND v(dout1_71) AT=95.025n

* CHECK dout1_72 Vdout1_72ck18 = 0.9 time = 95
.meas tran vdout1_72ck18 FIND v(dout1_72) AT=95.025n

* CHECK dout1_73 Vdout1_73ck18 = 0.9 time = 95
.meas tran vdout1_73ck18 FIND v(dout1_73) AT=95.025n

* CHECK dout1_74 Vdout1_74ck18 = 0 time = 95
.meas tran vdout1_74ck18 FIND v(dout1_74) AT=95.025n

* CHECK dout1_75 Vdout1_75ck18 = 0.9 time = 95
.meas tran vdout1_75ck18 FIND v(dout1_75) AT=95.025n

* CHECK dout1_76 Vdout1_76ck18 = 0.9 time = 95
.meas tran vdout1_76ck18 FIND v(dout1_76) AT=95.025n

* CHECK dout1_77 Vdout1_77ck18 = 0 time = 95
.meas tran vdout1_77ck18 FIND v(dout1_77) AT=95.025n

* CHECK dout1_78 Vdout1_78ck18 = 0.9 time = 95
.meas tran vdout1_78ck18 FIND v(dout1_78) AT=95.025n

* CHECK dout1_79 Vdout1_79ck18 = 0 time = 95
.meas tran vdout1_79ck18 FIND v(dout1_79) AT=95.025n

* CHECK dout1_80 Vdout1_80ck18 = 0.9 time = 95
.meas tran vdout1_80ck18 FIND v(dout1_80) AT=95.025n

* CHECK dout1_81 Vdout1_81ck18 = 0.9 time = 95
.meas tran vdout1_81ck18 FIND v(dout1_81) AT=95.025n

* CHECK dout1_82 Vdout1_82ck18 = 0 time = 95
.meas tran vdout1_82ck18 FIND v(dout1_82) AT=95.025n

* CHECK dout1_83 Vdout1_83ck18 = 0.9 time = 95
.meas tran vdout1_83ck18 FIND v(dout1_83) AT=95.025n

* CHECK dout1_84 Vdout1_84ck18 = 0 time = 95
.meas tran vdout1_84ck18 FIND v(dout1_84) AT=95.025n

* CHECK dout1_85 Vdout1_85ck18 = 0 time = 95
.meas tran vdout1_85ck18 FIND v(dout1_85) AT=95.025n

* CHECK dout1_86 Vdout1_86ck18 = 0 time = 95
.meas tran vdout1_86ck18 FIND v(dout1_86) AT=95.025n

* CHECK dout1_87 Vdout1_87ck18 = 0 time = 95
.meas tran vdout1_87ck18 FIND v(dout1_87) AT=95.025n

* CHECK dout1_88 Vdout1_88ck18 = 0.9 time = 95
.meas tran vdout1_88ck18 FIND v(dout1_88) AT=95.025n

* CHECK dout1_89 Vdout1_89ck18 = 0 time = 95
.meas tran vdout1_89ck18 FIND v(dout1_89) AT=95.025n

* CHECK dout1_90 Vdout1_90ck18 = 0.9 time = 95
.meas tran vdout1_90ck18 FIND v(dout1_90) AT=95.025n

* CHECK dout1_91 Vdout1_91ck18 = 0.9 time = 95
.meas tran vdout1_91ck18 FIND v(dout1_91) AT=95.025n

* CHECK dout1_92 Vdout1_92ck18 = 0.9 time = 95
.meas tran vdout1_92ck18 FIND v(dout1_92) AT=95.025n

* CHECK dout1_93 Vdout1_93ck18 = 0.9 time = 95
.meas tran vdout1_93ck18 FIND v(dout1_93) AT=95.025n

* CHECK dout1_94 Vdout1_94ck18 = 0 time = 95
.meas tran vdout1_94ck18 FIND v(dout1_94) AT=95.025n

* CHECK dout1_95 Vdout1_95ck18 = 0 time = 95
.meas tran vdout1_95ck18 FIND v(dout1_95) AT=95.025n

* CHECK dout1_96 Vdout1_96ck18 = 0.9 time = 95
.meas tran vdout1_96ck18 FIND v(dout1_96) AT=95.025n

* CHECK dout1_97 Vdout1_97ck18 = 0.9 time = 95
.meas tran vdout1_97ck18 FIND v(dout1_97) AT=95.025n

* CHECK dout1_98 Vdout1_98ck18 = 0 time = 95
.meas tran vdout1_98ck18 FIND v(dout1_98) AT=95.025n

* CHECK dout1_99 Vdout1_99ck18 = 0.9 time = 95
.meas tran vdout1_99ck18 FIND v(dout1_99) AT=95.025n

* CHECK dout1_100 Vdout1_100ck18 = 0 time = 95
.meas tran vdout1_100ck18 FIND v(dout1_100) AT=95.025n

* CHECK dout1_101 Vdout1_101ck18 = 0.9 time = 95
.meas tran vdout1_101ck18 FIND v(dout1_101) AT=95.025n

* CHECK dout1_102 Vdout1_102ck18 = 0.9 time = 95
.meas tran vdout1_102ck18 FIND v(dout1_102) AT=95.025n

* CHECK dout1_103 Vdout1_103ck18 = 0 time = 95
.meas tran vdout1_103ck18 FIND v(dout1_103) AT=95.025n

* CHECK dout1_104 Vdout1_104ck18 = 0.9 time = 95
.meas tran vdout1_104ck18 FIND v(dout1_104) AT=95.025n

* CHECK dout1_105 Vdout1_105ck18 = 0.9 time = 95
.meas tran vdout1_105ck18 FIND v(dout1_105) AT=95.025n

* CHECK dout1_106 Vdout1_106ck18 = 0 time = 95
.meas tran vdout1_106ck18 FIND v(dout1_106) AT=95.025n

* CHECK dout1_107 Vdout1_107ck18 = 0.9 time = 95
.meas tran vdout1_107ck18 FIND v(dout1_107) AT=95.025n

* CHECK dout1_108 Vdout1_108ck18 = 0.9 time = 95
.meas tran vdout1_108ck18 FIND v(dout1_108) AT=95.025n

* CHECK dout1_109 Vdout1_109ck18 = 0 time = 95
.meas tran vdout1_109ck18 FIND v(dout1_109) AT=95.025n

* CHECK dout1_110 Vdout1_110ck18 = 0.9 time = 95
.meas tran vdout1_110ck18 FIND v(dout1_110) AT=95.025n

* CHECK dout1_111 Vdout1_111ck18 = 0 time = 95
.meas tran vdout1_111ck18 FIND v(dout1_111) AT=95.025n

* CHECK dout1_112 Vdout1_112ck18 = 0.9 time = 95
.meas tran vdout1_112ck18 FIND v(dout1_112) AT=95.025n

* CHECK dout1_113 Vdout1_113ck18 = 0 time = 95
.meas tran vdout1_113ck18 FIND v(dout1_113) AT=95.025n

* CHECK dout1_114 Vdout1_114ck18 = 0.9 time = 95
.meas tran vdout1_114ck18 FIND v(dout1_114) AT=95.025n

* CHECK dout1_115 Vdout1_115ck18 = 0 time = 95
.meas tran vdout1_115ck18 FIND v(dout1_115) AT=95.025n

* CHECK dout1_116 Vdout1_116ck18 = 0 time = 95
.meas tran vdout1_116ck18 FIND v(dout1_116) AT=95.025n

* CHECK dout1_117 Vdout1_117ck18 = 0 time = 95
.meas tran vdout1_117ck18 FIND v(dout1_117) AT=95.025n

* CHECK dout1_118 Vdout1_118ck18 = 0 time = 95
.meas tran vdout1_118ck18 FIND v(dout1_118) AT=95.025n

* CHECK dout1_119 Vdout1_119ck18 = 0 time = 95
.meas tran vdout1_119ck18 FIND v(dout1_119) AT=95.025n

* CHECK dout1_0 Vdout1_0ck19 = 0 time = 100
.meas tran vdout1_0ck19 FIND v(dout1_0) AT=100.025n

* CHECK dout1_1 Vdout1_1ck19 = 0 time = 100
.meas tran vdout1_1ck19 FIND v(dout1_1) AT=100.025n

* CHECK dout1_2 Vdout1_2ck19 = 0.9 time = 100
.meas tran vdout1_2ck19 FIND v(dout1_2) AT=100.025n

* CHECK dout1_3 Vdout1_3ck19 = 0.9 time = 100
.meas tran vdout1_3ck19 FIND v(dout1_3) AT=100.025n

* CHECK dout1_4 Vdout1_4ck19 = 0.9 time = 100
.meas tran vdout1_4ck19 FIND v(dout1_4) AT=100.025n

* CHECK dout1_5 Vdout1_5ck19 = 0 time = 100
.meas tran vdout1_5ck19 FIND v(dout1_5) AT=100.025n

* CHECK dout1_6 Vdout1_6ck19 = 0.9 time = 100
.meas tran vdout1_6ck19 FIND v(dout1_6) AT=100.025n

* CHECK dout1_7 Vdout1_7ck19 = 0 time = 100
.meas tran vdout1_7ck19 FIND v(dout1_7) AT=100.025n

* CHECK dout1_8 Vdout1_8ck19 = 0.9 time = 100
.meas tran vdout1_8ck19 FIND v(dout1_8) AT=100.025n

* CHECK dout1_9 Vdout1_9ck19 = 0 time = 100
.meas tran vdout1_9ck19 FIND v(dout1_9) AT=100.025n

* CHECK dout1_10 Vdout1_10ck19 = 0 time = 100
.meas tran vdout1_10ck19 FIND v(dout1_10) AT=100.025n

* CHECK dout1_11 Vdout1_11ck19 = 0 time = 100
.meas tran vdout1_11ck19 FIND v(dout1_11) AT=100.025n

* CHECK dout1_12 Vdout1_12ck19 = 0.9 time = 100
.meas tran vdout1_12ck19 FIND v(dout1_12) AT=100.025n

* CHECK dout1_13 Vdout1_13ck19 = 0 time = 100
.meas tran vdout1_13ck19 FIND v(dout1_13) AT=100.025n

* CHECK dout1_14 Vdout1_14ck19 = 0 time = 100
.meas tran vdout1_14ck19 FIND v(dout1_14) AT=100.025n

* CHECK dout1_15 Vdout1_15ck19 = 0.9 time = 100
.meas tran vdout1_15ck19 FIND v(dout1_15) AT=100.025n

* CHECK dout1_16 Vdout1_16ck19 = 0 time = 100
.meas tran vdout1_16ck19 FIND v(dout1_16) AT=100.025n

* CHECK dout1_17 Vdout1_17ck19 = 0 time = 100
.meas tran vdout1_17ck19 FIND v(dout1_17) AT=100.025n

* CHECK dout1_18 Vdout1_18ck19 = 0.9 time = 100
.meas tran vdout1_18ck19 FIND v(dout1_18) AT=100.025n

* CHECK dout1_19 Vdout1_19ck19 = 0 time = 100
.meas tran vdout1_19ck19 FIND v(dout1_19) AT=100.025n

* CHECK dout1_20 Vdout1_20ck19 = 0 time = 100
.meas tran vdout1_20ck19 FIND v(dout1_20) AT=100.025n

* CHECK dout1_21 Vdout1_21ck19 = 0 time = 100
.meas tran vdout1_21ck19 FIND v(dout1_21) AT=100.025n

* CHECK dout1_22 Vdout1_22ck19 = 0.9 time = 100
.meas tran vdout1_22ck19 FIND v(dout1_22) AT=100.025n

* CHECK dout1_23 Vdout1_23ck19 = 0 time = 100
.meas tran vdout1_23ck19 FIND v(dout1_23) AT=100.025n

* CHECK dout1_24 Vdout1_24ck19 = 0 time = 100
.meas tran vdout1_24ck19 FIND v(dout1_24) AT=100.025n

* CHECK dout1_25 Vdout1_25ck19 = 0 time = 100
.meas tran vdout1_25ck19 FIND v(dout1_25) AT=100.025n

* CHECK dout1_26 Vdout1_26ck19 = 0.9 time = 100
.meas tran vdout1_26ck19 FIND v(dout1_26) AT=100.025n

* CHECK dout1_27 Vdout1_27ck19 = 0.9 time = 100
.meas tran vdout1_27ck19 FIND v(dout1_27) AT=100.025n

* CHECK dout1_28 Vdout1_28ck19 = 0 time = 100
.meas tran vdout1_28ck19 FIND v(dout1_28) AT=100.025n

* CHECK dout1_29 Vdout1_29ck19 = 0 time = 100
.meas tran vdout1_29ck19 FIND v(dout1_29) AT=100.025n

* CHECK dout1_30 Vdout1_30ck19 = 0.9 time = 100
.meas tran vdout1_30ck19 FIND v(dout1_30) AT=100.025n

* CHECK dout1_31 Vdout1_31ck19 = 0 time = 100
.meas tran vdout1_31ck19 FIND v(dout1_31) AT=100.025n

* CHECK dout1_32 Vdout1_32ck19 = 0 time = 100
.meas tran vdout1_32ck19 FIND v(dout1_32) AT=100.025n

* CHECK dout1_33 Vdout1_33ck19 = 0.9 time = 100
.meas tran vdout1_33ck19 FIND v(dout1_33) AT=100.025n

* CHECK dout1_34 Vdout1_34ck19 = 0.9 time = 100
.meas tran vdout1_34ck19 FIND v(dout1_34) AT=100.025n

* CHECK dout1_35 Vdout1_35ck19 = 0 time = 100
.meas tran vdout1_35ck19 FIND v(dout1_35) AT=100.025n

* CHECK dout1_36 Vdout1_36ck19 = 0 time = 100
.meas tran vdout1_36ck19 FIND v(dout1_36) AT=100.025n

* CHECK dout1_37 Vdout1_37ck19 = 0.9 time = 100
.meas tran vdout1_37ck19 FIND v(dout1_37) AT=100.025n

* CHECK dout1_38 Vdout1_38ck19 = 0 time = 100
.meas tran vdout1_38ck19 FIND v(dout1_38) AT=100.025n

* CHECK dout1_39 Vdout1_39ck19 = 0.9 time = 100
.meas tran vdout1_39ck19 FIND v(dout1_39) AT=100.025n

* CHECK dout1_40 Vdout1_40ck19 = 0 time = 100
.meas tran vdout1_40ck19 FIND v(dout1_40) AT=100.025n

* CHECK dout1_41 Vdout1_41ck19 = 0 time = 100
.meas tran vdout1_41ck19 FIND v(dout1_41) AT=100.025n

* CHECK dout1_42 Vdout1_42ck19 = 0 time = 100
.meas tran vdout1_42ck19 FIND v(dout1_42) AT=100.025n

* CHECK dout1_43 Vdout1_43ck19 = 0 time = 100
.meas tran vdout1_43ck19 FIND v(dout1_43) AT=100.025n

* CHECK dout1_44 Vdout1_44ck19 = 0 time = 100
.meas tran vdout1_44ck19 FIND v(dout1_44) AT=100.025n

* CHECK dout1_45 Vdout1_45ck19 = 0 time = 100
.meas tran vdout1_45ck19 FIND v(dout1_45) AT=100.025n

* CHECK dout1_46 Vdout1_46ck19 = 0 time = 100
.meas tran vdout1_46ck19 FIND v(dout1_46) AT=100.025n

* CHECK dout1_47 Vdout1_47ck19 = 0.9 time = 100
.meas tran vdout1_47ck19 FIND v(dout1_47) AT=100.025n

* CHECK dout1_48 Vdout1_48ck19 = 0.9 time = 100
.meas tran vdout1_48ck19 FIND v(dout1_48) AT=100.025n

* CHECK dout1_49 Vdout1_49ck19 = 0 time = 100
.meas tran vdout1_49ck19 FIND v(dout1_49) AT=100.025n

* CHECK dout1_50 Vdout1_50ck19 = 0.9 time = 100
.meas tran vdout1_50ck19 FIND v(dout1_50) AT=100.025n

* CHECK dout1_51 Vdout1_51ck19 = 0 time = 100
.meas tran vdout1_51ck19 FIND v(dout1_51) AT=100.025n

* CHECK dout1_52 Vdout1_52ck19 = 0.9 time = 100
.meas tran vdout1_52ck19 FIND v(dout1_52) AT=100.025n

* CHECK dout1_53 Vdout1_53ck19 = 0 time = 100
.meas tran vdout1_53ck19 FIND v(dout1_53) AT=100.025n

* CHECK dout1_54 Vdout1_54ck19 = 0 time = 100
.meas tran vdout1_54ck19 FIND v(dout1_54) AT=100.025n

* CHECK dout1_55 Vdout1_55ck19 = 0 time = 100
.meas tran vdout1_55ck19 FIND v(dout1_55) AT=100.025n

* CHECK dout1_56 Vdout1_56ck19 = 0.9 time = 100
.meas tran vdout1_56ck19 FIND v(dout1_56) AT=100.025n

* CHECK dout1_57 Vdout1_57ck19 = 0 time = 100
.meas tran vdout1_57ck19 FIND v(dout1_57) AT=100.025n

* CHECK dout1_58 Vdout1_58ck19 = 0.9 time = 100
.meas tran vdout1_58ck19 FIND v(dout1_58) AT=100.025n

* CHECK dout1_59 Vdout1_59ck19 = 0.9 time = 100
.meas tran vdout1_59ck19 FIND v(dout1_59) AT=100.025n

* CHECK dout1_60 Vdout1_60ck19 = 0.9 time = 100
.meas tran vdout1_60ck19 FIND v(dout1_60) AT=100.025n

* CHECK dout1_61 Vdout1_61ck19 = 0.9 time = 100
.meas tran vdout1_61ck19 FIND v(dout1_61) AT=100.025n

* CHECK dout1_62 Vdout1_62ck19 = 0.9 time = 100
.meas tran vdout1_62ck19 FIND v(dout1_62) AT=100.025n

* CHECK dout1_63 Vdout1_63ck19 = 0 time = 100
.meas tran vdout1_63ck19 FIND v(dout1_63) AT=100.025n

* CHECK dout1_64 Vdout1_64ck19 = 0.9 time = 100
.meas tran vdout1_64ck19 FIND v(dout1_64) AT=100.025n

* CHECK dout1_65 Vdout1_65ck19 = 0 time = 100
.meas tran vdout1_65ck19 FIND v(dout1_65) AT=100.025n

* CHECK dout1_66 Vdout1_66ck19 = 0.9 time = 100
.meas tran vdout1_66ck19 FIND v(dout1_66) AT=100.025n

* CHECK dout1_67 Vdout1_67ck19 = 0.9 time = 100
.meas tran vdout1_67ck19 FIND v(dout1_67) AT=100.025n

* CHECK dout1_68 Vdout1_68ck19 = 0.9 time = 100
.meas tran vdout1_68ck19 FIND v(dout1_68) AT=100.025n

* CHECK dout1_69 Vdout1_69ck19 = 0.9 time = 100
.meas tran vdout1_69ck19 FIND v(dout1_69) AT=100.025n

* CHECK dout1_70 Vdout1_70ck19 = 0.9 time = 100
.meas tran vdout1_70ck19 FIND v(dout1_70) AT=100.025n

* CHECK dout1_71 Vdout1_71ck19 = 0 time = 100
.meas tran vdout1_71ck19 FIND v(dout1_71) AT=100.025n

* CHECK dout1_72 Vdout1_72ck19 = 0 time = 100
.meas tran vdout1_72ck19 FIND v(dout1_72) AT=100.025n

* CHECK dout1_73 Vdout1_73ck19 = 0 time = 100
.meas tran vdout1_73ck19 FIND v(dout1_73) AT=100.025n

* CHECK dout1_74 Vdout1_74ck19 = 0.9 time = 100
.meas tran vdout1_74ck19 FIND v(dout1_74) AT=100.025n

* CHECK dout1_75 Vdout1_75ck19 = 0 time = 100
.meas tran vdout1_75ck19 FIND v(dout1_75) AT=100.025n

* CHECK dout1_76 Vdout1_76ck19 = 0.9 time = 100
.meas tran vdout1_76ck19 FIND v(dout1_76) AT=100.025n

* CHECK dout1_77 Vdout1_77ck19 = 0.9 time = 100
.meas tran vdout1_77ck19 FIND v(dout1_77) AT=100.025n

* CHECK dout1_78 Vdout1_78ck19 = 0 time = 100
.meas tran vdout1_78ck19 FIND v(dout1_78) AT=100.025n

* CHECK dout1_79 Vdout1_79ck19 = 0 time = 100
.meas tran vdout1_79ck19 FIND v(dout1_79) AT=100.025n

* CHECK dout1_80 Vdout1_80ck19 = 0.9 time = 100
.meas tran vdout1_80ck19 FIND v(dout1_80) AT=100.025n

* CHECK dout1_81 Vdout1_81ck19 = 0.9 time = 100
.meas tran vdout1_81ck19 FIND v(dout1_81) AT=100.025n

* CHECK dout1_82 Vdout1_82ck19 = 0 time = 100
.meas tran vdout1_82ck19 FIND v(dout1_82) AT=100.025n

* CHECK dout1_83 Vdout1_83ck19 = 0 time = 100
.meas tran vdout1_83ck19 FIND v(dout1_83) AT=100.025n

* CHECK dout1_84 Vdout1_84ck19 = 0.9 time = 100
.meas tran vdout1_84ck19 FIND v(dout1_84) AT=100.025n

* CHECK dout1_85 Vdout1_85ck19 = 0 time = 100
.meas tran vdout1_85ck19 FIND v(dout1_85) AT=100.025n

* CHECK dout1_86 Vdout1_86ck19 = 0.9 time = 100
.meas tran vdout1_86ck19 FIND v(dout1_86) AT=100.025n

* CHECK dout1_87 Vdout1_87ck19 = 0.9 time = 100
.meas tran vdout1_87ck19 FIND v(dout1_87) AT=100.025n

* CHECK dout1_88 Vdout1_88ck19 = 0.9 time = 100
.meas tran vdout1_88ck19 FIND v(dout1_88) AT=100.025n

* CHECK dout1_89 Vdout1_89ck19 = 0 time = 100
.meas tran vdout1_89ck19 FIND v(dout1_89) AT=100.025n

* CHECK dout1_90 Vdout1_90ck19 = 0.9 time = 100
.meas tran vdout1_90ck19 FIND v(dout1_90) AT=100.025n

* CHECK dout1_91 Vdout1_91ck19 = 0 time = 100
.meas tran vdout1_91ck19 FIND v(dout1_91) AT=100.025n

* CHECK dout1_92 Vdout1_92ck19 = 0.9 time = 100
.meas tran vdout1_92ck19 FIND v(dout1_92) AT=100.025n

* CHECK dout1_93 Vdout1_93ck19 = 0.9 time = 100
.meas tran vdout1_93ck19 FIND v(dout1_93) AT=100.025n

* CHECK dout1_94 Vdout1_94ck19 = 0 time = 100
.meas tran vdout1_94ck19 FIND v(dout1_94) AT=100.025n

* CHECK dout1_95 Vdout1_95ck19 = 0 time = 100
.meas tran vdout1_95ck19 FIND v(dout1_95) AT=100.025n

* CHECK dout1_96 Vdout1_96ck19 = 0.9 time = 100
.meas tran vdout1_96ck19 FIND v(dout1_96) AT=100.025n

* CHECK dout1_97 Vdout1_97ck19 = 0.9 time = 100
.meas tran vdout1_97ck19 FIND v(dout1_97) AT=100.025n

* CHECK dout1_98 Vdout1_98ck19 = 0.9 time = 100
.meas tran vdout1_98ck19 FIND v(dout1_98) AT=100.025n

* CHECK dout1_99 Vdout1_99ck19 = 0.9 time = 100
.meas tran vdout1_99ck19 FIND v(dout1_99) AT=100.025n

* CHECK dout1_100 Vdout1_100ck19 = 0 time = 100
.meas tran vdout1_100ck19 FIND v(dout1_100) AT=100.025n

* CHECK dout1_101 Vdout1_101ck19 = 0 time = 100
.meas tran vdout1_101ck19 FIND v(dout1_101) AT=100.025n

* CHECK dout1_102 Vdout1_102ck19 = 0 time = 100
.meas tran vdout1_102ck19 FIND v(dout1_102) AT=100.025n

* CHECK dout1_103 Vdout1_103ck19 = 0 time = 100
.meas tran vdout1_103ck19 FIND v(dout1_103) AT=100.025n

* CHECK dout1_104 Vdout1_104ck19 = 0.9 time = 100
.meas tran vdout1_104ck19 FIND v(dout1_104) AT=100.025n

* CHECK dout1_105 Vdout1_105ck19 = 0.9 time = 100
.meas tran vdout1_105ck19 FIND v(dout1_105) AT=100.025n

* CHECK dout1_106 Vdout1_106ck19 = 0.9 time = 100
.meas tran vdout1_106ck19 FIND v(dout1_106) AT=100.025n

* CHECK dout1_107 Vdout1_107ck19 = 0 time = 100
.meas tran vdout1_107ck19 FIND v(dout1_107) AT=100.025n

* CHECK dout1_108 Vdout1_108ck19 = 0.9 time = 100
.meas tran vdout1_108ck19 FIND v(dout1_108) AT=100.025n

* CHECK dout1_109 Vdout1_109ck19 = 0.9 time = 100
.meas tran vdout1_109ck19 FIND v(dout1_109) AT=100.025n

* CHECK dout1_110 Vdout1_110ck19 = 0 time = 100
.meas tran vdout1_110ck19 FIND v(dout1_110) AT=100.025n

* CHECK dout1_111 Vdout1_111ck19 = 0.9 time = 100
.meas tran vdout1_111ck19 FIND v(dout1_111) AT=100.025n

* CHECK dout1_112 Vdout1_112ck19 = 0 time = 100
.meas tran vdout1_112ck19 FIND v(dout1_112) AT=100.025n

* CHECK dout1_113 Vdout1_113ck19 = 0 time = 100
.meas tran vdout1_113ck19 FIND v(dout1_113) AT=100.025n

* CHECK dout1_114 Vdout1_114ck19 = 0 time = 100
.meas tran vdout1_114ck19 FIND v(dout1_114) AT=100.025n

* CHECK dout1_115 Vdout1_115ck19 = 0.9 time = 100
.meas tran vdout1_115ck19 FIND v(dout1_115) AT=100.025n

* CHECK dout1_116 Vdout1_116ck19 = 0 time = 100
.meas tran vdout1_116ck19 FIND v(dout1_116) AT=100.025n

* CHECK dout1_117 Vdout1_117ck19 = 0.9 time = 100
.meas tran vdout1_117ck19 FIND v(dout1_117) AT=100.025n

* CHECK dout1_118 Vdout1_118ck19 = 0.9 time = 100
.meas tran vdout1_118ck19 FIND v(dout1_118) AT=100.025n

* CHECK dout1_119 Vdout1_119ck19 = 0.9 time = 100
.meas tran vdout1_119ck19 FIND v(dout1_119) AT=100.025n

* CHECK dout1_0 Vdout1_0ck20 = 0 time = 105
.meas tran vdout1_0ck20 FIND v(dout1_0) AT=105.025n

* CHECK dout1_1 Vdout1_1ck20 = 0.9 time = 105
.meas tran vdout1_1ck20 FIND v(dout1_1) AT=105.025n

* CHECK dout1_2 Vdout1_2ck20 = 0 time = 105
.meas tran vdout1_2ck20 FIND v(dout1_2) AT=105.025n

* CHECK dout1_3 Vdout1_3ck20 = 0 time = 105
.meas tran vdout1_3ck20 FIND v(dout1_3) AT=105.025n

* CHECK dout1_4 Vdout1_4ck20 = 0.9 time = 105
.meas tran vdout1_4ck20 FIND v(dout1_4) AT=105.025n

* CHECK dout1_5 Vdout1_5ck20 = 0.9 time = 105
.meas tran vdout1_5ck20 FIND v(dout1_5) AT=105.025n

* CHECK dout1_6 Vdout1_6ck20 = 0 time = 105
.meas tran vdout1_6ck20 FIND v(dout1_6) AT=105.025n

* CHECK dout1_7 Vdout1_7ck20 = 0.9 time = 105
.meas tran vdout1_7ck20 FIND v(dout1_7) AT=105.025n

* CHECK dout1_8 Vdout1_8ck20 = 0.9 time = 105
.meas tran vdout1_8ck20 FIND v(dout1_8) AT=105.025n

* CHECK dout1_9 Vdout1_9ck20 = 0 time = 105
.meas tran vdout1_9ck20 FIND v(dout1_9) AT=105.025n

* CHECK dout1_10 Vdout1_10ck20 = 0.9 time = 105
.meas tran vdout1_10ck20 FIND v(dout1_10) AT=105.025n

* CHECK dout1_11 Vdout1_11ck20 = 0.9 time = 105
.meas tran vdout1_11ck20 FIND v(dout1_11) AT=105.025n

* CHECK dout1_12 Vdout1_12ck20 = 0.9 time = 105
.meas tran vdout1_12ck20 FIND v(dout1_12) AT=105.025n

* CHECK dout1_13 Vdout1_13ck20 = 0.9 time = 105
.meas tran vdout1_13ck20 FIND v(dout1_13) AT=105.025n

* CHECK dout1_14 Vdout1_14ck20 = 0 time = 105
.meas tran vdout1_14ck20 FIND v(dout1_14) AT=105.025n

* CHECK dout1_15 Vdout1_15ck20 = 0 time = 105
.meas tran vdout1_15ck20 FIND v(dout1_15) AT=105.025n

* CHECK dout1_16 Vdout1_16ck20 = 0.9 time = 105
.meas tran vdout1_16ck20 FIND v(dout1_16) AT=105.025n

* CHECK dout1_17 Vdout1_17ck20 = 0 time = 105
.meas tran vdout1_17ck20 FIND v(dout1_17) AT=105.025n

* CHECK dout1_18 Vdout1_18ck20 = 0.9 time = 105
.meas tran vdout1_18ck20 FIND v(dout1_18) AT=105.025n

* CHECK dout1_19 Vdout1_19ck20 = 0 time = 105
.meas tran vdout1_19ck20 FIND v(dout1_19) AT=105.025n

* CHECK dout1_20 Vdout1_20ck20 = 0 time = 105
.meas tran vdout1_20ck20 FIND v(dout1_20) AT=105.025n

* CHECK dout1_21 Vdout1_21ck20 = 0 time = 105
.meas tran vdout1_21ck20 FIND v(dout1_21) AT=105.025n

* CHECK dout1_22 Vdout1_22ck20 = 0 time = 105
.meas tran vdout1_22ck20 FIND v(dout1_22) AT=105.025n

* CHECK dout1_23 Vdout1_23ck20 = 0.9 time = 105
.meas tran vdout1_23ck20 FIND v(dout1_23) AT=105.025n

* CHECK dout1_24 Vdout1_24ck20 = 0 time = 105
.meas tran vdout1_24ck20 FIND v(dout1_24) AT=105.025n

* CHECK dout1_25 Vdout1_25ck20 = 0 time = 105
.meas tran vdout1_25ck20 FIND v(dout1_25) AT=105.025n

* CHECK dout1_26 Vdout1_26ck20 = 0.9 time = 105
.meas tran vdout1_26ck20 FIND v(dout1_26) AT=105.025n

* CHECK dout1_27 Vdout1_27ck20 = 0 time = 105
.meas tran vdout1_27ck20 FIND v(dout1_27) AT=105.025n

* CHECK dout1_28 Vdout1_28ck20 = 0.9 time = 105
.meas tran vdout1_28ck20 FIND v(dout1_28) AT=105.025n

* CHECK dout1_29 Vdout1_29ck20 = 0.9 time = 105
.meas tran vdout1_29ck20 FIND v(dout1_29) AT=105.025n

* CHECK dout1_30 Vdout1_30ck20 = 0.9 time = 105
.meas tran vdout1_30ck20 FIND v(dout1_30) AT=105.025n

* CHECK dout1_31 Vdout1_31ck20 = 0.9 time = 105
.meas tran vdout1_31ck20 FIND v(dout1_31) AT=105.025n

* CHECK dout1_32 Vdout1_32ck20 = 0.9 time = 105
.meas tran vdout1_32ck20 FIND v(dout1_32) AT=105.025n

* CHECK dout1_33 Vdout1_33ck20 = 0 time = 105
.meas tran vdout1_33ck20 FIND v(dout1_33) AT=105.025n

* CHECK dout1_34 Vdout1_34ck20 = 0 time = 105
.meas tran vdout1_34ck20 FIND v(dout1_34) AT=105.025n

* CHECK dout1_35 Vdout1_35ck20 = 0.9 time = 105
.meas tran vdout1_35ck20 FIND v(dout1_35) AT=105.025n

* CHECK dout1_36 Vdout1_36ck20 = 0 time = 105
.meas tran vdout1_36ck20 FIND v(dout1_36) AT=105.025n

* CHECK dout1_37 Vdout1_37ck20 = 0 time = 105
.meas tran vdout1_37ck20 FIND v(dout1_37) AT=105.025n

* CHECK dout1_38 Vdout1_38ck20 = 0.9 time = 105
.meas tran vdout1_38ck20 FIND v(dout1_38) AT=105.025n

* CHECK dout1_39 Vdout1_39ck20 = 0 time = 105
.meas tran vdout1_39ck20 FIND v(dout1_39) AT=105.025n

* CHECK dout1_40 Vdout1_40ck20 = 0.9 time = 105
.meas tran vdout1_40ck20 FIND v(dout1_40) AT=105.025n

* CHECK dout1_41 Vdout1_41ck20 = 0.9 time = 105
.meas tran vdout1_41ck20 FIND v(dout1_41) AT=105.025n

* CHECK dout1_42 Vdout1_42ck20 = 0 time = 105
.meas tran vdout1_42ck20 FIND v(dout1_42) AT=105.025n

* CHECK dout1_43 Vdout1_43ck20 = 0.9 time = 105
.meas tran vdout1_43ck20 FIND v(dout1_43) AT=105.025n

* CHECK dout1_44 Vdout1_44ck20 = 0 time = 105
.meas tran vdout1_44ck20 FIND v(dout1_44) AT=105.025n

* CHECK dout1_45 Vdout1_45ck20 = 0 time = 105
.meas tran vdout1_45ck20 FIND v(dout1_45) AT=105.025n

* CHECK dout1_46 Vdout1_46ck20 = 0 time = 105
.meas tran vdout1_46ck20 FIND v(dout1_46) AT=105.025n

* CHECK dout1_47 Vdout1_47ck20 = 0 time = 105
.meas tran vdout1_47ck20 FIND v(dout1_47) AT=105.025n

* CHECK dout1_48 Vdout1_48ck20 = 0.9 time = 105
.meas tran vdout1_48ck20 FIND v(dout1_48) AT=105.025n

* CHECK dout1_49 Vdout1_49ck20 = 0.9 time = 105
.meas tran vdout1_49ck20 FIND v(dout1_49) AT=105.025n

* CHECK dout1_50 Vdout1_50ck20 = 0.9 time = 105
.meas tran vdout1_50ck20 FIND v(dout1_50) AT=105.025n

* CHECK dout1_51 Vdout1_51ck20 = 0 time = 105
.meas tran vdout1_51ck20 FIND v(dout1_51) AT=105.025n

* CHECK dout1_52 Vdout1_52ck20 = 0 time = 105
.meas tran vdout1_52ck20 FIND v(dout1_52) AT=105.025n

* CHECK dout1_53 Vdout1_53ck20 = 0 time = 105
.meas tran vdout1_53ck20 FIND v(dout1_53) AT=105.025n

* CHECK dout1_54 Vdout1_54ck20 = 0 time = 105
.meas tran vdout1_54ck20 FIND v(dout1_54) AT=105.025n

* CHECK dout1_55 Vdout1_55ck20 = 0 time = 105
.meas tran vdout1_55ck20 FIND v(dout1_55) AT=105.025n

* CHECK dout1_56 Vdout1_56ck20 = 0.9 time = 105
.meas tran vdout1_56ck20 FIND v(dout1_56) AT=105.025n

* CHECK dout1_57 Vdout1_57ck20 = 0 time = 105
.meas tran vdout1_57ck20 FIND v(dout1_57) AT=105.025n

* CHECK dout1_58 Vdout1_58ck20 = 0.9 time = 105
.meas tran vdout1_58ck20 FIND v(dout1_58) AT=105.025n

* CHECK dout1_59 Vdout1_59ck20 = 0.9 time = 105
.meas tran vdout1_59ck20 FIND v(dout1_59) AT=105.025n

* CHECK dout1_60 Vdout1_60ck20 = 0 time = 105
.meas tran vdout1_60ck20 FIND v(dout1_60) AT=105.025n

* CHECK dout1_61 Vdout1_61ck20 = 0.9 time = 105
.meas tran vdout1_61ck20 FIND v(dout1_61) AT=105.025n

* CHECK dout1_62 Vdout1_62ck20 = 0 time = 105
.meas tran vdout1_62ck20 FIND v(dout1_62) AT=105.025n

* CHECK dout1_63 Vdout1_63ck20 = 0.9 time = 105
.meas tran vdout1_63ck20 FIND v(dout1_63) AT=105.025n

* CHECK dout1_64 Vdout1_64ck20 = 0 time = 105
.meas tran vdout1_64ck20 FIND v(dout1_64) AT=105.025n

* CHECK dout1_65 Vdout1_65ck20 = 0.9 time = 105
.meas tran vdout1_65ck20 FIND v(dout1_65) AT=105.025n

* CHECK dout1_66 Vdout1_66ck20 = 0.9 time = 105
.meas tran vdout1_66ck20 FIND v(dout1_66) AT=105.025n

* CHECK dout1_67 Vdout1_67ck20 = 0 time = 105
.meas tran vdout1_67ck20 FIND v(dout1_67) AT=105.025n

* CHECK dout1_68 Vdout1_68ck20 = 0 time = 105
.meas tran vdout1_68ck20 FIND v(dout1_68) AT=105.025n

* CHECK dout1_69 Vdout1_69ck20 = 0.9 time = 105
.meas tran vdout1_69ck20 FIND v(dout1_69) AT=105.025n

* CHECK dout1_70 Vdout1_70ck20 = 0.9 time = 105
.meas tran vdout1_70ck20 FIND v(dout1_70) AT=105.025n

* CHECK dout1_71 Vdout1_71ck20 = 0 time = 105
.meas tran vdout1_71ck20 FIND v(dout1_71) AT=105.025n

* CHECK dout1_72 Vdout1_72ck20 = 0.9 time = 105
.meas tran vdout1_72ck20 FIND v(dout1_72) AT=105.025n

* CHECK dout1_73 Vdout1_73ck20 = 0.9 time = 105
.meas tran vdout1_73ck20 FIND v(dout1_73) AT=105.025n

* CHECK dout1_74 Vdout1_74ck20 = 0 time = 105
.meas tran vdout1_74ck20 FIND v(dout1_74) AT=105.025n

* CHECK dout1_75 Vdout1_75ck20 = 0.9 time = 105
.meas tran vdout1_75ck20 FIND v(dout1_75) AT=105.025n

* CHECK dout1_76 Vdout1_76ck20 = 0 time = 105
.meas tran vdout1_76ck20 FIND v(dout1_76) AT=105.025n

* CHECK dout1_77 Vdout1_77ck20 = 0.9 time = 105
.meas tran vdout1_77ck20 FIND v(dout1_77) AT=105.025n

* CHECK dout1_78 Vdout1_78ck20 = 0.9 time = 105
.meas tran vdout1_78ck20 FIND v(dout1_78) AT=105.025n

* CHECK dout1_79 Vdout1_79ck20 = 0 time = 105
.meas tran vdout1_79ck20 FIND v(dout1_79) AT=105.025n

* CHECK dout1_80 Vdout1_80ck20 = 0.9 time = 105
.meas tran vdout1_80ck20 FIND v(dout1_80) AT=105.025n

* CHECK dout1_81 Vdout1_81ck20 = 0 time = 105
.meas tran vdout1_81ck20 FIND v(dout1_81) AT=105.025n

* CHECK dout1_82 Vdout1_82ck20 = 0.9 time = 105
.meas tran vdout1_82ck20 FIND v(dout1_82) AT=105.025n

* CHECK dout1_83 Vdout1_83ck20 = 0 time = 105
.meas tran vdout1_83ck20 FIND v(dout1_83) AT=105.025n

* CHECK dout1_84 Vdout1_84ck20 = 0.9 time = 105
.meas tran vdout1_84ck20 FIND v(dout1_84) AT=105.025n

* CHECK dout1_85 Vdout1_85ck20 = 0.9 time = 105
.meas tran vdout1_85ck20 FIND v(dout1_85) AT=105.025n

* CHECK dout1_86 Vdout1_86ck20 = 0.9 time = 105
.meas tran vdout1_86ck20 FIND v(dout1_86) AT=105.025n

* CHECK dout1_87 Vdout1_87ck20 = 0.9 time = 105
.meas tran vdout1_87ck20 FIND v(dout1_87) AT=105.025n

* CHECK dout1_88 Vdout1_88ck20 = 0 time = 105
.meas tran vdout1_88ck20 FIND v(dout1_88) AT=105.025n

* CHECK dout1_89 Vdout1_89ck20 = 0.9 time = 105
.meas tran vdout1_89ck20 FIND v(dout1_89) AT=105.025n

* CHECK dout1_90 Vdout1_90ck20 = 0.9 time = 105
.meas tran vdout1_90ck20 FIND v(dout1_90) AT=105.025n

* CHECK dout1_91 Vdout1_91ck20 = 0 time = 105
.meas tran vdout1_91ck20 FIND v(dout1_91) AT=105.025n

* CHECK dout1_92 Vdout1_92ck20 = 0 time = 105
.meas tran vdout1_92ck20 FIND v(dout1_92) AT=105.025n

* CHECK dout1_93 Vdout1_93ck20 = 0.9 time = 105
.meas tran vdout1_93ck20 FIND v(dout1_93) AT=105.025n

* CHECK dout1_94 Vdout1_94ck20 = 0.9 time = 105
.meas tran vdout1_94ck20 FIND v(dout1_94) AT=105.025n

* CHECK dout1_95 Vdout1_95ck20 = 0 time = 105
.meas tran vdout1_95ck20 FIND v(dout1_95) AT=105.025n

* CHECK dout1_96 Vdout1_96ck20 = 0.9 time = 105
.meas tran vdout1_96ck20 FIND v(dout1_96) AT=105.025n

* CHECK dout1_97 Vdout1_97ck20 = 0 time = 105
.meas tran vdout1_97ck20 FIND v(dout1_97) AT=105.025n

* CHECK dout1_98 Vdout1_98ck20 = 0.9 time = 105
.meas tran vdout1_98ck20 FIND v(dout1_98) AT=105.025n

* CHECK dout1_99 Vdout1_99ck20 = 0 time = 105
.meas tran vdout1_99ck20 FIND v(dout1_99) AT=105.025n

* CHECK dout1_100 Vdout1_100ck20 = 0.9 time = 105
.meas tran vdout1_100ck20 FIND v(dout1_100) AT=105.025n

* CHECK dout1_101 Vdout1_101ck20 = 0 time = 105
.meas tran vdout1_101ck20 FIND v(dout1_101) AT=105.025n

* CHECK dout1_102 Vdout1_102ck20 = 0.9 time = 105
.meas tran vdout1_102ck20 FIND v(dout1_102) AT=105.025n

* CHECK dout1_103 Vdout1_103ck20 = 0.9 time = 105
.meas tran vdout1_103ck20 FIND v(dout1_103) AT=105.025n

* CHECK dout1_104 Vdout1_104ck20 = 0 time = 105
.meas tran vdout1_104ck20 FIND v(dout1_104) AT=105.025n

* CHECK dout1_105 Vdout1_105ck20 = 0 time = 105
.meas tran vdout1_105ck20 FIND v(dout1_105) AT=105.025n

* CHECK dout1_106 Vdout1_106ck20 = 0 time = 105
.meas tran vdout1_106ck20 FIND v(dout1_106) AT=105.025n

* CHECK dout1_107 Vdout1_107ck20 = 0 time = 105
.meas tran vdout1_107ck20 FIND v(dout1_107) AT=105.025n

* CHECK dout1_108 Vdout1_108ck20 = 0.9 time = 105
.meas tran vdout1_108ck20 FIND v(dout1_108) AT=105.025n

* CHECK dout1_109 Vdout1_109ck20 = 0 time = 105
.meas tran vdout1_109ck20 FIND v(dout1_109) AT=105.025n

* CHECK dout1_110 Vdout1_110ck20 = 0.9 time = 105
.meas tran vdout1_110ck20 FIND v(dout1_110) AT=105.025n

* CHECK dout1_111 Vdout1_111ck20 = 0.9 time = 105
.meas tran vdout1_111ck20 FIND v(dout1_111) AT=105.025n

* CHECK dout1_112 Vdout1_112ck20 = 0 time = 105
.meas tran vdout1_112ck20 FIND v(dout1_112) AT=105.025n

* CHECK dout1_113 Vdout1_113ck20 = 0 time = 105
.meas tran vdout1_113ck20 FIND v(dout1_113) AT=105.025n

* CHECK dout1_114 Vdout1_114ck20 = 0 time = 105
.meas tran vdout1_114ck20 FIND v(dout1_114) AT=105.025n

* CHECK dout1_115 Vdout1_115ck20 = 0.9 time = 105
.meas tran vdout1_115ck20 FIND v(dout1_115) AT=105.025n

* CHECK dout1_116 Vdout1_116ck20 = 0.9 time = 105
.meas tran vdout1_116ck20 FIND v(dout1_116) AT=105.025n

* CHECK dout1_117 Vdout1_117ck20 = 0 time = 105
.meas tran vdout1_117ck20 FIND v(dout1_117) AT=105.025n

* CHECK dout1_118 Vdout1_118ck20 = 0.9 time = 105
.meas tran vdout1_118ck20 FIND v(dout1_118) AT=105.025n

* CHECK dout1_119 Vdout1_119ck20 = 0.9 time = 105
.meas tran vdout1_119ck20 FIND v(dout1_119) AT=105.025n

* CHECK dout1_0 Vdout1_0ck24 = 0 time = 125
.meas tran vdout1_0ck24 FIND v(dout1_0) AT=125.025n

* CHECK dout1_1 Vdout1_1ck24 = 0.9 time = 125
.meas tran vdout1_1ck24 FIND v(dout1_1) AT=125.025n

* CHECK dout1_2 Vdout1_2ck24 = 0.9 time = 125
.meas tran vdout1_2ck24 FIND v(dout1_2) AT=125.025n

* CHECK dout1_3 Vdout1_3ck24 = 0 time = 125
.meas tran vdout1_3ck24 FIND v(dout1_3) AT=125.025n

* CHECK dout1_4 Vdout1_4ck24 = 0.9 time = 125
.meas tran vdout1_4ck24 FIND v(dout1_4) AT=125.025n

* CHECK dout1_5 Vdout1_5ck24 = 0 time = 125
.meas tran vdout1_5ck24 FIND v(dout1_5) AT=125.025n

* CHECK dout1_6 Vdout1_6ck24 = 0.9 time = 125
.meas tran vdout1_6ck24 FIND v(dout1_6) AT=125.025n

* CHECK dout1_7 Vdout1_7ck24 = 0 time = 125
.meas tran vdout1_7ck24 FIND v(dout1_7) AT=125.025n

* CHECK dout1_8 Vdout1_8ck24 = 0 time = 125
.meas tran vdout1_8ck24 FIND v(dout1_8) AT=125.025n

* CHECK dout1_9 Vdout1_9ck24 = 0.9 time = 125
.meas tran vdout1_9ck24 FIND v(dout1_9) AT=125.025n

* CHECK dout1_10 Vdout1_10ck24 = 0.9 time = 125
.meas tran vdout1_10ck24 FIND v(dout1_10) AT=125.025n

* CHECK dout1_11 Vdout1_11ck24 = 0 time = 125
.meas tran vdout1_11ck24 FIND v(dout1_11) AT=125.025n

* CHECK dout1_12 Vdout1_12ck24 = 0.9 time = 125
.meas tran vdout1_12ck24 FIND v(dout1_12) AT=125.025n

* CHECK dout1_13 Vdout1_13ck24 = 0.9 time = 125
.meas tran vdout1_13ck24 FIND v(dout1_13) AT=125.025n

* CHECK dout1_14 Vdout1_14ck24 = 0 time = 125
.meas tran vdout1_14ck24 FIND v(dout1_14) AT=125.025n

* CHECK dout1_15 Vdout1_15ck24 = 0.9 time = 125
.meas tran vdout1_15ck24 FIND v(dout1_15) AT=125.025n

* CHECK dout1_16 Vdout1_16ck24 = 0 time = 125
.meas tran vdout1_16ck24 FIND v(dout1_16) AT=125.025n

* CHECK dout1_17 Vdout1_17ck24 = 0.9 time = 125
.meas tran vdout1_17ck24 FIND v(dout1_17) AT=125.025n

* CHECK dout1_18 Vdout1_18ck24 = 0.9 time = 125
.meas tran vdout1_18ck24 FIND v(dout1_18) AT=125.025n

* CHECK dout1_19 Vdout1_19ck24 = 0 time = 125
.meas tran vdout1_19ck24 FIND v(dout1_19) AT=125.025n

* CHECK dout1_20 Vdout1_20ck24 = 0.9 time = 125
.meas tran vdout1_20ck24 FIND v(dout1_20) AT=125.025n

* CHECK dout1_21 Vdout1_21ck24 = 0.9 time = 125
.meas tran vdout1_21ck24 FIND v(dout1_21) AT=125.025n

* CHECK dout1_22 Vdout1_22ck24 = 0 time = 125
.meas tran vdout1_22ck24 FIND v(dout1_22) AT=125.025n

* CHECK dout1_23 Vdout1_23ck24 = 0.9 time = 125
.meas tran vdout1_23ck24 FIND v(dout1_23) AT=125.025n

* CHECK dout1_24 Vdout1_24ck24 = 0 time = 125
.meas tran vdout1_24ck24 FIND v(dout1_24) AT=125.025n

* CHECK dout1_25 Vdout1_25ck24 = 0.9 time = 125
.meas tran vdout1_25ck24 FIND v(dout1_25) AT=125.025n

* CHECK dout1_26 Vdout1_26ck24 = 0 time = 125
.meas tran vdout1_26ck24 FIND v(dout1_26) AT=125.025n

* CHECK dout1_27 Vdout1_27ck24 = 0.9 time = 125
.meas tran vdout1_27ck24 FIND v(dout1_27) AT=125.025n

* CHECK dout1_28 Vdout1_28ck24 = 0 time = 125
.meas tran vdout1_28ck24 FIND v(dout1_28) AT=125.025n

* CHECK dout1_29 Vdout1_29ck24 = 0 time = 125
.meas tran vdout1_29ck24 FIND v(dout1_29) AT=125.025n

* CHECK dout1_30 Vdout1_30ck24 = 0 time = 125
.meas tran vdout1_30ck24 FIND v(dout1_30) AT=125.025n

* CHECK dout1_31 Vdout1_31ck24 = 0.9 time = 125
.meas tran vdout1_31ck24 FIND v(dout1_31) AT=125.025n

* CHECK dout1_32 Vdout1_32ck24 = 0 time = 125
.meas tran vdout1_32ck24 FIND v(dout1_32) AT=125.025n

* CHECK dout1_33 Vdout1_33ck24 = 0 time = 125
.meas tran vdout1_33ck24 FIND v(dout1_33) AT=125.025n

* CHECK dout1_34 Vdout1_34ck24 = 0.9 time = 125
.meas tran vdout1_34ck24 FIND v(dout1_34) AT=125.025n

* CHECK dout1_35 Vdout1_35ck24 = 0 time = 125
.meas tran vdout1_35ck24 FIND v(dout1_35) AT=125.025n

* CHECK dout1_36 Vdout1_36ck24 = 0 time = 125
.meas tran vdout1_36ck24 FIND v(dout1_36) AT=125.025n

* CHECK dout1_37 Vdout1_37ck24 = 0 time = 125
.meas tran vdout1_37ck24 FIND v(dout1_37) AT=125.025n

* CHECK dout1_38 Vdout1_38ck24 = 0.9 time = 125
.meas tran vdout1_38ck24 FIND v(dout1_38) AT=125.025n

* CHECK dout1_39 Vdout1_39ck24 = 0 time = 125
.meas tran vdout1_39ck24 FIND v(dout1_39) AT=125.025n

* CHECK dout1_40 Vdout1_40ck24 = 0 time = 125
.meas tran vdout1_40ck24 FIND v(dout1_40) AT=125.025n

* CHECK dout1_41 Vdout1_41ck24 = 0.9 time = 125
.meas tran vdout1_41ck24 FIND v(dout1_41) AT=125.025n

* CHECK dout1_42 Vdout1_42ck24 = 0 time = 125
.meas tran vdout1_42ck24 FIND v(dout1_42) AT=125.025n

* CHECK dout1_43 Vdout1_43ck24 = 0.9 time = 125
.meas tran vdout1_43ck24 FIND v(dout1_43) AT=125.025n

* CHECK dout1_44 Vdout1_44ck24 = 0 time = 125
.meas tran vdout1_44ck24 FIND v(dout1_44) AT=125.025n

* CHECK dout1_45 Vdout1_45ck24 = 0 time = 125
.meas tran vdout1_45ck24 FIND v(dout1_45) AT=125.025n

* CHECK dout1_46 Vdout1_46ck24 = 0.9 time = 125
.meas tran vdout1_46ck24 FIND v(dout1_46) AT=125.025n

* CHECK dout1_47 Vdout1_47ck24 = 0.9 time = 125
.meas tran vdout1_47ck24 FIND v(dout1_47) AT=125.025n

* CHECK dout1_48 Vdout1_48ck24 = 0.9 time = 125
.meas tran vdout1_48ck24 FIND v(dout1_48) AT=125.025n

* CHECK dout1_49 Vdout1_49ck24 = 0.9 time = 125
.meas tran vdout1_49ck24 FIND v(dout1_49) AT=125.025n

* CHECK dout1_50 Vdout1_50ck24 = 0.9 time = 125
.meas tran vdout1_50ck24 FIND v(dout1_50) AT=125.025n

* CHECK dout1_51 Vdout1_51ck24 = 0.9 time = 125
.meas tran vdout1_51ck24 FIND v(dout1_51) AT=125.025n

* CHECK dout1_52 Vdout1_52ck24 = 0.9 time = 125
.meas tran vdout1_52ck24 FIND v(dout1_52) AT=125.025n

* CHECK dout1_53 Vdout1_53ck24 = 0 time = 125
.meas tran vdout1_53ck24 FIND v(dout1_53) AT=125.025n

* CHECK dout1_54 Vdout1_54ck24 = 0.9 time = 125
.meas tran vdout1_54ck24 FIND v(dout1_54) AT=125.025n

* CHECK dout1_55 Vdout1_55ck24 = 0.9 time = 125
.meas tran vdout1_55ck24 FIND v(dout1_55) AT=125.025n

* CHECK dout1_56 Vdout1_56ck24 = 0 time = 125
.meas tran vdout1_56ck24 FIND v(dout1_56) AT=125.025n

* CHECK dout1_57 Vdout1_57ck24 = 0.9 time = 125
.meas tran vdout1_57ck24 FIND v(dout1_57) AT=125.025n

* CHECK dout1_58 Vdout1_58ck24 = 0 time = 125
.meas tran vdout1_58ck24 FIND v(dout1_58) AT=125.025n

* CHECK dout1_59 Vdout1_59ck24 = 0.9 time = 125
.meas tran vdout1_59ck24 FIND v(dout1_59) AT=125.025n

* CHECK dout1_60 Vdout1_60ck24 = 0.9 time = 125
.meas tran vdout1_60ck24 FIND v(dout1_60) AT=125.025n

* CHECK dout1_61 Vdout1_61ck24 = 0 time = 125
.meas tran vdout1_61ck24 FIND v(dout1_61) AT=125.025n

* CHECK dout1_62 Vdout1_62ck24 = 0.9 time = 125
.meas tran vdout1_62ck24 FIND v(dout1_62) AT=125.025n

* CHECK dout1_63 Vdout1_63ck24 = 0 time = 125
.meas tran vdout1_63ck24 FIND v(dout1_63) AT=125.025n

* CHECK dout1_64 Vdout1_64ck24 = 0.9 time = 125
.meas tran vdout1_64ck24 FIND v(dout1_64) AT=125.025n

* CHECK dout1_65 Vdout1_65ck24 = 0.9 time = 125
.meas tran vdout1_65ck24 FIND v(dout1_65) AT=125.025n

* CHECK dout1_66 Vdout1_66ck24 = 0.9 time = 125
.meas tran vdout1_66ck24 FIND v(dout1_66) AT=125.025n

* CHECK dout1_67 Vdout1_67ck24 = 0 time = 125
.meas tran vdout1_67ck24 FIND v(dout1_67) AT=125.025n

* CHECK dout1_68 Vdout1_68ck24 = 0.9 time = 125
.meas tran vdout1_68ck24 FIND v(dout1_68) AT=125.025n

* CHECK dout1_69 Vdout1_69ck24 = 0 time = 125
.meas tran vdout1_69ck24 FIND v(dout1_69) AT=125.025n

* CHECK dout1_70 Vdout1_70ck24 = 0.9 time = 125
.meas tran vdout1_70ck24 FIND v(dout1_70) AT=125.025n

* CHECK dout1_71 Vdout1_71ck24 = 0 time = 125
.meas tran vdout1_71ck24 FIND v(dout1_71) AT=125.025n

* CHECK dout1_72 Vdout1_72ck24 = 0.9 time = 125
.meas tran vdout1_72ck24 FIND v(dout1_72) AT=125.025n

* CHECK dout1_73 Vdout1_73ck24 = 0 time = 125
.meas tran vdout1_73ck24 FIND v(dout1_73) AT=125.025n

* CHECK dout1_74 Vdout1_74ck24 = 0.9 time = 125
.meas tran vdout1_74ck24 FIND v(dout1_74) AT=125.025n

* CHECK dout1_75 Vdout1_75ck24 = 0.9 time = 125
.meas tran vdout1_75ck24 FIND v(dout1_75) AT=125.025n

* CHECK dout1_76 Vdout1_76ck24 = 0 time = 125
.meas tran vdout1_76ck24 FIND v(dout1_76) AT=125.025n

* CHECK dout1_77 Vdout1_77ck24 = 0 time = 125
.meas tran vdout1_77ck24 FIND v(dout1_77) AT=125.025n

* CHECK dout1_78 Vdout1_78ck24 = 0.9 time = 125
.meas tran vdout1_78ck24 FIND v(dout1_78) AT=125.025n

* CHECK dout1_79 Vdout1_79ck24 = 0.9 time = 125
.meas tran vdout1_79ck24 FIND v(dout1_79) AT=125.025n

* CHECK dout1_80 Vdout1_80ck24 = 0.9 time = 125
.meas tran vdout1_80ck24 FIND v(dout1_80) AT=125.025n

* CHECK dout1_81 Vdout1_81ck24 = 0 time = 125
.meas tran vdout1_81ck24 FIND v(dout1_81) AT=125.025n

* CHECK dout1_82 Vdout1_82ck24 = 0 time = 125
.meas tran vdout1_82ck24 FIND v(dout1_82) AT=125.025n

* CHECK dout1_83 Vdout1_83ck24 = 0.9 time = 125
.meas tran vdout1_83ck24 FIND v(dout1_83) AT=125.025n

* CHECK dout1_84 Vdout1_84ck24 = 0.9 time = 125
.meas tran vdout1_84ck24 FIND v(dout1_84) AT=125.025n

* CHECK dout1_85 Vdout1_85ck24 = 0.9 time = 125
.meas tran vdout1_85ck24 FIND v(dout1_85) AT=125.025n

* CHECK dout1_86 Vdout1_86ck24 = 0 time = 125
.meas tran vdout1_86ck24 FIND v(dout1_86) AT=125.025n

* CHECK dout1_87 Vdout1_87ck24 = 0.9 time = 125
.meas tran vdout1_87ck24 FIND v(dout1_87) AT=125.025n

* CHECK dout1_88 Vdout1_88ck24 = 0.9 time = 125
.meas tran vdout1_88ck24 FIND v(dout1_88) AT=125.025n

* CHECK dout1_89 Vdout1_89ck24 = 0 time = 125
.meas tran vdout1_89ck24 FIND v(dout1_89) AT=125.025n

* CHECK dout1_90 Vdout1_90ck24 = 0.9 time = 125
.meas tran vdout1_90ck24 FIND v(dout1_90) AT=125.025n

* CHECK dout1_91 Vdout1_91ck24 = 0.9 time = 125
.meas tran vdout1_91ck24 FIND v(dout1_91) AT=125.025n

* CHECK dout1_92 Vdout1_92ck24 = 0 time = 125
.meas tran vdout1_92ck24 FIND v(dout1_92) AT=125.025n

* CHECK dout1_93 Vdout1_93ck24 = 0.9 time = 125
.meas tran vdout1_93ck24 FIND v(dout1_93) AT=125.025n

* CHECK dout1_94 Vdout1_94ck24 = 0.9 time = 125
.meas tran vdout1_94ck24 FIND v(dout1_94) AT=125.025n

* CHECK dout1_95 Vdout1_95ck24 = 0.9 time = 125
.meas tran vdout1_95ck24 FIND v(dout1_95) AT=125.025n

* CHECK dout1_96 Vdout1_96ck24 = 0 time = 125
.meas tran vdout1_96ck24 FIND v(dout1_96) AT=125.025n

* CHECK dout1_97 Vdout1_97ck24 = 0.9 time = 125
.meas tran vdout1_97ck24 FIND v(dout1_97) AT=125.025n

* CHECK dout1_98 Vdout1_98ck24 = 0 time = 125
.meas tran vdout1_98ck24 FIND v(dout1_98) AT=125.025n

* CHECK dout1_99 Vdout1_99ck24 = 0 time = 125
.meas tran vdout1_99ck24 FIND v(dout1_99) AT=125.025n

* CHECK dout1_100 Vdout1_100ck24 = 0.9 time = 125
.meas tran vdout1_100ck24 FIND v(dout1_100) AT=125.025n

* CHECK dout1_101 Vdout1_101ck24 = 0 time = 125
.meas tran vdout1_101ck24 FIND v(dout1_101) AT=125.025n

* CHECK dout1_102 Vdout1_102ck24 = 0 time = 125
.meas tran vdout1_102ck24 FIND v(dout1_102) AT=125.025n

* CHECK dout1_103 Vdout1_103ck24 = 0.9 time = 125
.meas tran vdout1_103ck24 FIND v(dout1_103) AT=125.025n

* CHECK dout1_104 Vdout1_104ck24 = 0 time = 125
.meas tran vdout1_104ck24 FIND v(dout1_104) AT=125.025n

* CHECK dout1_105 Vdout1_105ck24 = 0.9 time = 125
.meas tran vdout1_105ck24 FIND v(dout1_105) AT=125.025n

* CHECK dout1_106 Vdout1_106ck24 = 0.9 time = 125
.meas tran vdout1_106ck24 FIND v(dout1_106) AT=125.025n

* CHECK dout1_107 Vdout1_107ck24 = 0.9 time = 125
.meas tran vdout1_107ck24 FIND v(dout1_107) AT=125.025n

* CHECK dout1_108 Vdout1_108ck24 = 0.9 time = 125
.meas tran vdout1_108ck24 FIND v(dout1_108) AT=125.025n

* CHECK dout1_109 Vdout1_109ck24 = 0 time = 125
.meas tran vdout1_109ck24 FIND v(dout1_109) AT=125.025n

* CHECK dout1_110 Vdout1_110ck24 = 0 time = 125
.meas tran vdout1_110ck24 FIND v(dout1_110) AT=125.025n

* CHECK dout1_111 Vdout1_111ck24 = 0 time = 125
.meas tran vdout1_111ck24 FIND v(dout1_111) AT=125.025n

* CHECK dout1_112 Vdout1_112ck24 = 0.9 time = 125
.meas tran vdout1_112ck24 FIND v(dout1_112) AT=125.025n

* CHECK dout1_113 Vdout1_113ck24 = 0 time = 125
.meas tran vdout1_113ck24 FIND v(dout1_113) AT=125.025n

* CHECK dout1_114 Vdout1_114ck24 = 0.9 time = 125
.meas tran vdout1_114ck24 FIND v(dout1_114) AT=125.025n

* CHECK dout1_115 Vdout1_115ck24 = 0.9 time = 125
.meas tran vdout1_115ck24 FIND v(dout1_115) AT=125.025n

* CHECK dout1_116 Vdout1_116ck24 = 0 time = 125
.meas tran vdout1_116ck24 FIND v(dout1_116) AT=125.025n

* CHECK dout1_117 Vdout1_117ck24 = 0 time = 125
.meas tran vdout1_117ck24 FIND v(dout1_117) AT=125.025n

* CHECK dout1_118 Vdout1_118ck24 = 0 time = 125
.meas tran vdout1_118ck24 FIND v(dout1_118) AT=125.025n

* CHECK dout1_119 Vdout1_119ck24 = 0 time = 125
.meas tran vdout1_119ck24 FIND v(dout1_119) AT=125.025n

* CHECK dout1_0 Vdout1_0ck25 = 0 time = 130
.meas tran vdout1_0ck25 FIND v(dout1_0) AT=130.025n

* CHECK dout1_1 Vdout1_1ck25 = 0 time = 130
.meas tran vdout1_1ck25 FIND v(dout1_1) AT=130.025n

* CHECK dout1_2 Vdout1_2ck25 = 0.9 time = 130
.meas tran vdout1_2ck25 FIND v(dout1_2) AT=130.025n

* CHECK dout1_3 Vdout1_3ck25 = 0.9 time = 130
.meas tran vdout1_3ck25 FIND v(dout1_3) AT=130.025n

* CHECK dout1_4 Vdout1_4ck25 = 0.9 time = 130
.meas tran vdout1_4ck25 FIND v(dout1_4) AT=130.025n

* CHECK dout1_5 Vdout1_5ck25 = 0 time = 130
.meas tran vdout1_5ck25 FIND v(dout1_5) AT=130.025n

* CHECK dout1_6 Vdout1_6ck25 = 0.9 time = 130
.meas tran vdout1_6ck25 FIND v(dout1_6) AT=130.025n

* CHECK dout1_7 Vdout1_7ck25 = 0 time = 130
.meas tran vdout1_7ck25 FIND v(dout1_7) AT=130.025n

* CHECK dout1_8 Vdout1_8ck25 = 0.9 time = 130
.meas tran vdout1_8ck25 FIND v(dout1_8) AT=130.025n

* CHECK dout1_9 Vdout1_9ck25 = 0 time = 130
.meas tran vdout1_9ck25 FIND v(dout1_9) AT=130.025n

* CHECK dout1_10 Vdout1_10ck25 = 0 time = 130
.meas tran vdout1_10ck25 FIND v(dout1_10) AT=130.025n

* CHECK dout1_11 Vdout1_11ck25 = 0 time = 130
.meas tran vdout1_11ck25 FIND v(dout1_11) AT=130.025n

* CHECK dout1_12 Vdout1_12ck25 = 0.9 time = 130
.meas tran vdout1_12ck25 FIND v(dout1_12) AT=130.025n

* CHECK dout1_13 Vdout1_13ck25 = 0 time = 130
.meas tran vdout1_13ck25 FIND v(dout1_13) AT=130.025n

* CHECK dout1_14 Vdout1_14ck25 = 0 time = 130
.meas tran vdout1_14ck25 FIND v(dout1_14) AT=130.025n

* CHECK dout1_15 Vdout1_15ck25 = 0.9 time = 130
.meas tran vdout1_15ck25 FIND v(dout1_15) AT=130.025n

* CHECK dout1_16 Vdout1_16ck25 = 0 time = 130
.meas tran vdout1_16ck25 FIND v(dout1_16) AT=130.025n

* CHECK dout1_17 Vdout1_17ck25 = 0 time = 130
.meas tran vdout1_17ck25 FIND v(dout1_17) AT=130.025n

* CHECK dout1_18 Vdout1_18ck25 = 0.9 time = 130
.meas tran vdout1_18ck25 FIND v(dout1_18) AT=130.025n

* CHECK dout1_19 Vdout1_19ck25 = 0 time = 130
.meas tran vdout1_19ck25 FIND v(dout1_19) AT=130.025n

* CHECK dout1_20 Vdout1_20ck25 = 0 time = 130
.meas tran vdout1_20ck25 FIND v(dout1_20) AT=130.025n

* CHECK dout1_21 Vdout1_21ck25 = 0 time = 130
.meas tran vdout1_21ck25 FIND v(dout1_21) AT=130.025n

* CHECK dout1_22 Vdout1_22ck25 = 0.9 time = 130
.meas tran vdout1_22ck25 FIND v(dout1_22) AT=130.025n

* CHECK dout1_23 Vdout1_23ck25 = 0 time = 130
.meas tran vdout1_23ck25 FIND v(dout1_23) AT=130.025n

* CHECK dout1_24 Vdout1_24ck25 = 0 time = 130
.meas tran vdout1_24ck25 FIND v(dout1_24) AT=130.025n

* CHECK dout1_25 Vdout1_25ck25 = 0 time = 130
.meas tran vdout1_25ck25 FIND v(dout1_25) AT=130.025n

* CHECK dout1_26 Vdout1_26ck25 = 0.9 time = 130
.meas tran vdout1_26ck25 FIND v(dout1_26) AT=130.025n

* CHECK dout1_27 Vdout1_27ck25 = 0.9 time = 130
.meas tran vdout1_27ck25 FIND v(dout1_27) AT=130.025n

* CHECK dout1_28 Vdout1_28ck25 = 0 time = 130
.meas tran vdout1_28ck25 FIND v(dout1_28) AT=130.025n

* CHECK dout1_29 Vdout1_29ck25 = 0 time = 130
.meas tran vdout1_29ck25 FIND v(dout1_29) AT=130.025n

* CHECK dout1_30 Vdout1_30ck25 = 0.9 time = 130
.meas tran vdout1_30ck25 FIND v(dout1_30) AT=130.025n

* CHECK dout1_31 Vdout1_31ck25 = 0 time = 130
.meas tran vdout1_31ck25 FIND v(dout1_31) AT=130.025n

* CHECK dout1_32 Vdout1_32ck25 = 0 time = 130
.meas tran vdout1_32ck25 FIND v(dout1_32) AT=130.025n

* CHECK dout1_33 Vdout1_33ck25 = 0.9 time = 130
.meas tran vdout1_33ck25 FIND v(dout1_33) AT=130.025n

* CHECK dout1_34 Vdout1_34ck25 = 0.9 time = 130
.meas tran vdout1_34ck25 FIND v(dout1_34) AT=130.025n

* CHECK dout1_35 Vdout1_35ck25 = 0 time = 130
.meas tran vdout1_35ck25 FIND v(dout1_35) AT=130.025n

* CHECK dout1_36 Vdout1_36ck25 = 0 time = 130
.meas tran vdout1_36ck25 FIND v(dout1_36) AT=130.025n

* CHECK dout1_37 Vdout1_37ck25 = 0.9 time = 130
.meas tran vdout1_37ck25 FIND v(dout1_37) AT=130.025n

* CHECK dout1_38 Vdout1_38ck25 = 0 time = 130
.meas tran vdout1_38ck25 FIND v(dout1_38) AT=130.025n

* CHECK dout1_39 Vdout1_39ck25 = 0.9 time = 130
.meas tran vdout1_39ck25 FIND v(dout1_39) AT=130.025n

* CHECK dout1_40 Vdout1_40ck25 = 0 time = 130
.meas tran vdout1_40ck25 FIND v(dout1_40) AT=130.025n

* CHECK dout1_41 Vdout1_41ck25 = 0 time = 130
.meas tran vdout1_41ck25 FIND v(dout1_41) AT=130.025n

* CHECK dout1_42 Vdout1_42ck25 = 0 time = 130
.meas tran vdout1_42ck25 FIND v(dout1_42) AT=130.025n

* CHECK dout1_43 Vdout1_43ck25 = 0 time = 130
.meas tran vdout1_43ck25 FIND v(dout1_43) AT=130.025n

* CHECK dout1_44 Vdout1_44ck25 = 0 time = 130
.meas tran vdout1_44ck25 FIND v(dout1_44) AT=130.025n

* CHECK dout1_45 Vdout1_45ck25 = 0 time = 130
.meas tran vdout1_45ck25 FIND v(dout1_45) AT=130.025n

* CHECK dout1_46 Vdout1_46ck25 = 0 time = 130
.meas tran vdout1_46ck25 FIND v(dout1_46) AT=130.025n

* CHECK dout1_47 Vdout1_47ck25 = 0.9 time = 130
.meas tran vdout1_47ck25 FIND v(dout1_47) AT=130.025n

* CHECK dout1_48 Vdout1_48ck25 = 0.9 time = 130
.meas tran vdout1_48ck25 FIND v(dout1_48) AT=130.025n

* CHECK dout1_49 Vdout1_49ck25 = 0 time = 130
.meas tran vdout1_49ck25 FIND v(dout1_49) AT=130.025n

* CHECK dout1_50 Vdout1_50ck25 = 0.9 time = 130
.meas tran vdout1_50ck25 FIND v(dout1_50) AT=130.025n

* CHECK dout1_51 Vdout1_51ck25 = 0 time = 130
.meas tran vdout1_51ck25 FIND v(dout1_51) AT=130.025n

* CHECK dout1_52 Vdout1_52ck25 = 0.9 time = 130
.meas tran vdout1_52ck25 FIND v(dout1_52) AT=130.025n

* CHECK dout1_53 Vdout1_53ck25 = 0 time = 130
.meas tran vdout1_53ck25 FIND v(dout1_53) AT=130.025n

* CHECK dout1_54 Vdout1_54ck25 = 0 time = 130
.meas tran vdout1_54ck25 FIND v(dout1_54) AT=130.025n

* CHECK dout1_55 Vdout1_55ck25 = 0 time = 130
.meas tran vdout1_55ck25 FIND v(dout1_55) AT=130.025n

* CHECK dout1_56 Vdout1_56ck25 = 0.9 time = 130
.meas tran vdout1_56ck25 FIND v(dout1_56) AT=130.025n

* CHECK dout1_57 Vdout1_57ck25 = 0 time = 130
.meas tran vdout1_57ck25 FIND v(dout1_57) AT=130.025n

* CHECK dout1_58 Vdout1_58ck25 = 0.9 time = 130
.meas tran vdout1_58ck25 FIND v(dout1_58) AT=130.025n

* CHECK dout1_59 Vdout1_59ck25 = 0.9 time = 130
.meas tran vdout1_59ck25 FIND v(dout1_59) AT=130.025n

* CHECK dout1_60 Vdout1_60ck25 = 0.9 time = 130
.meas tran vdout1_60ck25 FIND v(dout1_60) AT=130.025n

* CHECK dout1_61 Vdout1_61ck25 = 0.9 time = 130
.meas tran vdout1_61ck25 FIND v(dout1_61) AT=130.025n

* CHECK dout1_62 Vdout1_62ck25 = 0.9 time = 130
.meas tran vdout1_62ck25 FIND v(dout1_62) AT=130.025n

* CHECK dout1_63 Vdout1_63ck25 = 0 time = 130
.meas tran vdout1_63ck25 FIND v(dout1_63) AT=130.025n

* CHECK dout1_64 Vdout1_64ck25 = 0.9 time = 130
.meas tran vdout1_64ck25 FIND v(dout1_64) AT=130.025n

* CHECK dout1_65 Vdout1_65ck25 = 0 time = 130
.meas tran vdout1_65ck25 FIND v(dout1_65) AT=130.025n

* CHECK dout1_66 Vdout1_66ck25 = 0.9 time = 130
.meas tran vdout1_66ck25 FIND v(dout1_66) AT=130.025n

* CHECK dout1_67 Vdout1_67ck25 = 0.9 time = 130
.meas tran vdout1_67ck25 FIND v(dout1_67) AT=130.025n

* CHECK dout1_68 Vdout1_68ck25 = 0.9 time = 130
.meas tran vdout1_68ck25 FIND v(dout1_68) AT=130.025n

* CHECK dout1_69 Vdout1_69ck25 = 0.9 time = 130
.meas tran vdout1_69ck25 FIND v(dout1_69) AT=130.025n

* CHECK dout1_70 Vdout1_70ck25 = 0.9 time = 130
.meas tran vdout1_70ck25 FIND v(dout1_70) AT=130.025n

* CHECK dout1_71 Vdout1_71ck25 = 0 time = 130
.meas tran vdout1_71ck25 FIND v(dout1_71) AT=130.025n

* CHECK dout1_72 Vdout1_72ck25 = 0 time = 130
.meas tran vdout1_72ck25 FIND v(dout1_72) AT=130.025n

* CHECK dout1_73 Vdout1_73ck25 = 0 time = 130
.meas tran vdout1_73ck25 FIND v(dout1_73) AT=130.025n

* CHECK dout1_74 Vdout1_74ck25 = 0.9 time = 130
.meas tran vdout1_74ck25 FIND v(dout1_74) AT=130.025n

* CHECK dout1_75 Vdout1_75ck25 = 0 time = 130
.meas tran vdout1_75ck25 FIND v(dout1_75) AT=130.025n

* CHECK dout1_76 Vdout1_76ck25 = 0.9 time = 130
.meas tran vdout1_76ck25 FIND v(dout1_76) AT=130.025n

* CHECK dout1_77 Vdout1_77ck25 = 0.9 time = 130
.meas tran vdout1_77ck25 FIND v(dout1_77) AT=130.025n

* CHECK dout1_78 Vdout1_78ck25 = 0 time = 130
.meas tran vdout1_78ck25 FIND v(dout1_78) AT=130.025n

* CHECK dout1_79 Vdout1_79ck25 = 0 time = 130
.meas tran vdout1_79ck25 FIND v(dout1_79) AT=130.025n

* CHECK dout1_80 Vdout1_80ck25 = 0.9 time = 130
.meas tran vdout1_80ck25 FIND v(dout1_80) AT=130.025n

* CHECK dout1_81 Vdout1_81ck25 = 0.9 time = 130
.meas tran vdout1_81ck25 FIND v(dout1_81) AT=130.025n

* CHECK dout1_82 Vdout1_82ck25 = 0 time = 130
.meas tran vdout1_82ck25 FIND v(dout1_82) AT=130.025n

* CHECK dout1_83 Vdout1_83ck25 = 0 time = 130
.meas tran vdout1_83ck25 FIND v(dout1_83) AT=130.025n

* CHECK dout1_84 Vdout1_84ck25 = 0.9 time = 130
.meas tran vdout1_84ck25 FIND v(dout1_84) AT=130.025n

* CHECK dout1_85 Vdout1_85ck25 = 0 time = 130
.meas tran vdout1_85ck25 FIND v(dout1_85) AT=130.025n

* CHECK dout1_86 Vdout1_86ck25 = 0.9 time = 130
.meas tran vdout1_86ck25 FIND v(dout1_86) AT=130.025n

* CHECK dout1_87 Vdout1_87ck25 = 0.9 time = 130
.meas tran vdout1_87ck25 FIND v(dout1_87) AT=130.025n

* CHECK dout1_88 Vdout1_88ck25 = 0.9 time = 130
.meas tran vdout1_88ck25 FIND v(dout1_88) AT=130.025n

* CHECK dout1_89 Vdout1_89ck25 = 0 time = 130
.meas tran vdout1_89ck25 FIND v(dout1_89) AT=130.025n

* CHECK dout1_90 Vdout1_90ck25 = 0.9 time = 130
.meas tran vdout1_90ck25 FIND v(dout1_90) AT=130.025n

* CHECK dout1_91 Vdout1_91ck25 = 0 time = 130
.meas tran vdout1_91ck25 FIND v(dout1_91) AT=130.025n

* CHECK dout1_92 Vdout1_92ck25 = 0.9 time = 130
.meas tran vdout1_92ck25 FIND v(dout1_92) AT=130.025n

* CHECK dout1_93 Vdout1_93ck25 = 0.9 time = 130
.meas tran vdout1_93ck25 FIND v(dout1_93) AT=130.025n

* CHECK dout1_94 Vdout1_94ck25 = 0.9 time = 130
.meas tran vdout1_94ck25 FIND v(dout1_94) AT=130.025n

* CHECK dout1_95 Vdout1_95ck25 = 0 time = 130
.meas tran vdout1_95ck25 FIND v(dout1_95) AT=130.025n

* CHECK dout1_96 Vdout1_96ck25 = 0.9 time = 130
.meas tran vdout1_96ck25 FIND v(dout1_96) AT=130.025n

* CHECK dout1_97 Vdout1_97ck25 = 0.9 time = 130
.meas tran vdout1_97ck25 FIND v(dout1_97) AT=130.025n

* CHECK dout1_98 Vdout1_98ck25 = 0.9 time = 130
.meas tran vdout1_98ck25 FIND v(dout1_98) AT=130.025n

* CHECK dout1_99 Vdout1_99ck25 = 0 time = 130
.meas tran vdout1_99ck25 FIND v(dout1_99) AT=130.025n

* CHECK dout1_100 Vdout1_100ck25 = 0 time = 130
.meas tran vdout1_100ck25 FIND v(dout1_100) AT=130.025n

* CHECK dout1_101 Vdout1_101ck25 = 0.9 time = 130
.meas tran vdout1_101ck25 FIND v(dout1_101) AT=130.025n

* CHECK dout1_102 Vdout1_102ck25 = 0.9 time = 130
.meas tran vdout1_102ck25 FIND v(dout1_102) AT=130.025n

* CHECK dout1_103 Vdout1_103ck25 = 0.9 time = 130
.meas tran vdout1_103ck25 FIND v(dout1_103) AT=130.025n

* CHECK dout1_104 Vdout1_104ck25 = 0.9 time = 130
.meas tran vdout1_104ck25 FIND v(dout1_104) AT=130.025n

* CHECK dout1_105 Vdout1_105ck25 = 0 time = 130
.meas tran vdout1_105ck25 FIND v(dout1_105) AT=130.025n

* CHECK dout1_106 Vdout1_106ck25 = 0 time = 130
.meas tran vdout1_106ck25 FIND v(dout1_106) AT=130.025n

* CHECK dout1_107 Vdout1_107ck25 = 0 time = 130
.meas tran vdout1_107ck25 FIND v(dout1_107) AT=130.025n

* CHECK dout1_108 Vdout1_108ck25 = 0.9 time = 130
.meas tran vdout1_108ck25 FIND v(dout1_108) AT=130.025n

* CHECK dout1_109 Vdout1_109ck25 = 0 time = 130
.meas tran vdout1_109ck25 FIND v(dout1_109) AT=130.025n

* CHECK dout1_110 Vdout1_110ck25 = 0 time = 130
.meas tran vdout1_110ck25 FIND v(dout1_110) AT=130.025n

* CHECK dout1_111 Vdout1_111ck25 = 0.9 time = 130
.meas tran vdout1_111ck25 FIND v(dout1_111) AT=130.025n

* CHECK dout1_112 Vdout1_112ck25 = 0 time = 130
.meas tran vdout1_112ck25 FIND v(dout1_112) AT=130.025n

* CHECK dout1_113 Vdout1_113ck25 = 0.9 time = 130
.meas tran vdout1_113ck25 FIND v(dout1_113) AT=130.025n

* CHECK dout1_114 Vdout1_114ck25 = 0 time = 130
.meas tran vdout1_114ck25 FIND v(dout1_114) AT=130.025n

* CHECK dout1_115 Vdout1_115ck25 = 0 time = 130
.meas tran vdout1_115ck25 FIND v(dout1_115) AT=130.025n

* CHECK dout1_116 Vdout1_116ck25 = 0 time = 130
.meas tran vdout1_116ck25 FIND v(dout1_116) AT=130.025n

* CHECK dout1_117 Vdout1_117ck25 = 0 time = 130
.meas tran vdout1_117ck25 FIND v(dout1_117) AT=130.025n

* CHECK dout1_118 Vdout1_118ck25 = 0.9 time = 130
.meas tran vdout1_118ck25 FIND v(dout1_118) AT=130.025n

* CHECK dout1_119 Vdout1_119ck25 = 0.9 time = 130
.meas tran vdout1_119ck25 FIND v(dout1_119) AT=130.025n

* CHECK dout1_0 Vdout1_0ck28 = 0 time = 145
.meas tran vdout1_0ck28 FIND v(dout1_0) AT=145.025n

* CHECK dout1_1 Vdout1_1ck28 = 0.9 time = 145
.meas tran vdout1_1ck28 FIND v(dout1_1) AT=145.025n

* CHECK dout1_2 Vdout1_2ck28 = 0.9 time = 145
.meas tran vdout1_2ck28 FIND v(dout1_2) AT=145.025n

* CHECK dout1_3 Vdout1_3ck28 = 0 time = 145
.meas tran vdout1_3ck28 FIND v(dout1_3) AT=145.025n

* CHECK dout1_4 Vdout1_4ck28 = 0.9 time = 145
.meas tran vdout1_4ck28 FIND v(dout1_4) AT=145.025n

* CHECK dout1_5 Vdout1_5ck28 = 0 time = 145
.meas tran vdout1_5ck28 FIND v(dout1_5) AT=145.025n

* CHECK dout1_6 Vdout1_6ck28 = 0.9 time = 145
.meas tran vdout1_6ck28 FIND v(dout1_6) AT=145.025n

* CHECK dout1_7 Vdout1_7ck28 = 0 time = 145
.meas tran vdout1_7ck28 FIND v(dout1_7) AT=145.025n

* CHECK dout1_8 Vdout1_8ck28 = 0 time = 145
.meas tran vdout1_8ck28 FIND v(dout1_8) AT=145.025n

* CHECK dout1_9 Vdout1_9ck28 = 0.9 time = 145
.meas tran vdout1_9ck28 FIND v(dout1_9) AT=145.025n

* CHECK dout1_10 Vdout1_10ck28 = 0.9 time = 145
.meas tran vdout1_10ck28 FIND v(dout1_10) AT=145.025n

* CHECK dout1_11 Vdout1_11ck28 = 0 time = 145
.meas tran vdout1_11ck28 FIND v(dout1_11) AT=145.025n

* CHECK dout1_12 Vdout1_12ck28 = 0.9 time = 145
.meas tran vdout1_12ck28 FIND v(dout1_12) AT=145.025n

* CHECK dout1_13 Vdout1_13ck28 = 0.9 time = 145
.meas tran vdout1_13ck28 FIND v(dout1_13) AT=145.025n

* CHECK dout1_14 Vdout1_14ck28 = 0 time = 145
.meas tran vdout1_14ck28 FIND v(dout1_14) AT=145.025n

* CHECK dout1_15 Vdout1_15ck28 = 0.9 time = 145
.meas tran vdout1_15ck28 FIND v(dout1_15) AT=145.025n

* CHECK dout1_16 Vdout1_16ck28 = 0 time = 145
.meas tran vdout1_16ck28 FIND v(dout1_16) AT=145.025n

* CHECK dout1_17 Vdout1_17ck28 = 0.9 time = 145
.meas tran vdout1_17ck28 FIND v(dout1_17) AT=145.025n

* CHECK dout1_18 Vdout1_18ck28 = 0.9 time = 145
.meas tran vdout1_18ck28 FIND v(dout1_18) AT=145.025n

* CHECK dout1_19 Vdout1_19ck28 = 0 time = 145
.meas tran vdout1_19ck28 FIND v(dout1_19) AT=145.025n

* CHECK dout1_20 Vdout1_20ck28 = 0.9 time = 145
.meas tran vdout1_20ck28 FIND v(dout1_20) AT=145.025n

* CHECK dout1_21 Vdout1_21ck28 = 0.9 time = 145
.meas tran vdout1_21ck28 FIND v(dout1_21) AT=145.025n

* CHECK dout1_22 Vdout1_22ck28 = 0 time = 145
.meas tran vdout1_22ck28 FIND v(dout1_22) AT=145.025n

* CHECK dout1_23 Vdout1_23ck28 = 0.9 time = 145
.meas tran vdout1_23ck28 FIND v(dout1_23) AT=145.025n

* CHECK dout1_24 Vdout1_24ck28 = 0 time = 145
.meas tran vdout1_24ck28 FIND v(dout1_24) AT=145.025n

* CHECK dout1_25 Vdout1_25ck28 = 0.9 time = 145
.meas tran vdout1_25ck28 FIND v(dout1_25) AT=145.025n

* CHECK dout1_26 Vdout1_26ck28 = 0 time = 145
.meas tran vdout1_26ck28 FIND v(dout1_26) AT=145.025n

* CHECK dout1_27 Vdout1_27ck28 = 0.9 time = 145
.meas tran vdout1_27ck28 FIND v(dout1_27) AT=145.025n

* CHECK dout1_28 Vdout1_28ck28 = 0 time = 145
.meas tran vdout1_28ck28 FIND v(dout1_28) AT=145.025n

* CHECK dout1_29 Vdout1_29ck28 = 0 time = 145
.meas tran vdout1_29ck28 FIND v(dout1_29) AT=145.025n

* CHECK dout1_30 Vdout1_30ck28 = 0 time = 145
.meas tran vdout1_30ck28 FIND v(dout1_30) AT=145.025n

* CHECK dout1_31 Vdout1_31ck28 = 0.9 time = 145
.meas tran vdout1_31ck28 FIND v(dout1_31) AT=145.025n

* CHECK dout1_32 Vdout1_32ck28 = 0 time = 145
.meas tran vdout1_32ck28 FIND v(dout1_32) AT=145.025n

* CHECK dout1_33 Vdout1_33ck28 = 0 time = 145
.meas tran vdout1_33ck28 FIND v(dout1_33) AT=145.025n

* CHECK dout1_34 Vdout1_34ck28 = 0.9 time = 145
.meas tran vdout1_34ck28 FIND v(dout1_34) AT=145.025n

* CHECK dout1_35 Vdout1_35ck28 = 0 time = 145
.meas tran vdout1_35ck28 FIND v(dout1_35) AT=145.025n

* CHECK dout1_36 Vdout1_36ck28 = 0 time = 145
.meas tran vdout1_36ck28 FIND v(dout1_36) AT=145.025n

* CHECK dout1_37 Vdout1_37ck28 = 0 time = 145
.meas tran vdout1_37ck28 FIND v(dout1_37) AT=145.025n

* CHECK dout1_38 Vdout1_38ck28 = 0.9 time = 145
.meas tran vdout1_38ck28 FIND v(dout1_38) AT=145.025n

* CHECK dout1_39 Vdout1_39ck28 = 0 time = 145
.meas tran vdout1_39ck28 FIND v(dout1_39) AT=145.025n

* CHECK dout1_40 Vdout1_40ck28 = 0 time = 145
.meas tran vdout1_40ck28 FIND v(dout1_40) AT=145.025n

* CHECK dout1_41 Vdout1_41ck28 = 0.9 time = 145
.meas tran vdout1_41ck28 FIND v(dout1_41) AT=145.025n

* CHECK dout1_42 Vdout1_42ck28 = 0 time = 145
.meas tran vdout1_42ck28 FIND v(dout1_42) AT=145.025n

* CHECK dout1_43 Vdout1_43ck28 = 0.9 time = 145
.meas tran vdout1_43ck28 FIND v(dout1_43) AT=145.025n

* CHECK dout1_44 Vdout1_44ck28 = 0 time = 145
.meas tran vdout1_44ck28 FIND v(dout1_44) AT=145.025n

* CHECK dout1_45 Vdout1_45ck28 = 0 time = 145
.meas tran vdout1_45ck28 FIND v(dout1_45) AT=145.025n

* CHECK dout1_46 Vdout1_46ck28 = 0.9 time = 145
.meas tran vdout1_46ck28 FIND v(dout1_46) AT=145.025n

* CHECK dout1_47 Vdout1_47ck28 = 0.9 time = 145
.meas tran vdout1_47ck28 FIND v(dout1_47) AT=145.025n

* CHECK dout1_48 Vdout1_48ck28 = 0.9 time = 145
.meas tran vdout1_48ck28 FIND v(dout1_48) AT=145.025n

* CHECK dout1_49 Vdout1_49ck28 = 0.9 time = 145
.meas tran vdout1_49ck28 FIND v(dout1_49) AT=145.025n

* CHECK dout1_50 Vdout1_50ck28 = 0.9 time = 145
.meas tran vdout1_50ck28 FIND v(dout1_50) AT=145.025n

* CHECK dout1_51 Vdout1_51ck28 = 0.9 time = 145
.meas tran vdout1_51ck28 FIND v(dout1_51) AT=145.025n

* CHECK dout1_52 Vdout1_52ck28 = 0.9 time = 145
.meas tran vdout1_52ck28 FIND v(dout1_52) AT=145.025n

* CHECK dout1_53 Vdout1_53ck28 = 0 time = 145
.meas tran vdout1_53ck28 FIND v(dout1_53) AT=145.025n

* CHECK dout1_54 Vdout1_54ck28 = 0.9 time = 145
.meas tran vdout1_54ck28 FIND v(dout1_54) AT=145.025n

* CHECK dout1_55 Vdout1_55ck28 = 0.9 time = 145
.meas tran vdout1_55ck28 FIND v(dout1_55) AT=145.025n

* CHECK dout1_56 Vdout1_56ck28 = 0 time = 145
.meas tran vdout1_56ck28 FIND v(dout1_56) AT=145.025n

* CHECK dout1_57 Vdout1_57ck28 = 0.9 time = 145
.meas tran vdout1_57ck28 FIND v(dout1_57) AT=145.025n

* CHECK dout1_58 Vdout1_58ck28 = 0 time = 145
.meas tran vdout1_58ck28 FIND v(dout1_58) AT=145.025n

* CHECK dout1_59 Vdout1_59ck28 = 0.9 time = 145
.meas tran vdout1_59ck28 FIND v(dout1_59) AT=145.025n

* CHECK dout1_60 Vdout1_60ck28 = 0.9 time = 145
.meas tran vdout1_60ck28 FIND v(dout1_60) AT=145.025n

* CHECK dout1_61 Vdout1_61ck28 = 0 time = 145
.meas tran vdout1_61ck28 FIND v(dout1_61) AT=145.025n

* CHECK dout1_62 Vdout1_62ck28 = 0.9 time = 145
.meas tran vdout1_62ck28 FIND v(dout1_62) AT=145.025n

* CHECK dout1_63 Vdout1_63ck28 = 0 time = 145
.meas tran vdout1_63ck28 FIND v(dout1_63) AT=145.025n

* CHECK dout1_64 Vdout1_64ck28 = 0.9 time = 145
.meas tran vdout1_64ck28 FIND v(dout1_64) AT=145.025n

* CHECK dout1_65 Vdout1_65ck28 = 0.9 time = 145
.meas tran vdout1_65ck28 FIND v(dout1_65) AT=145.025n

* CHECK dout1_66 Vdout1_66ck28 = 0.9 time = 145
.meas tran vdout1_66ck28 FIND v(dout1_66) AT=145.025n

* CHECK dout1_67 Vdout1_67ck28 = 0 time = 145
.meas tran vdout1_67ck28 FIND v(dout1_67) AT=145.025n

* CHECK dout1_68 Vdout1_68ck28 = 0.9 time = 145
.meas tran vdout1_68ck28 FIND v(dout1_68) AT=145.025n

* CHECK dout1_69 Vdout1_69ck28 = 0 time = 145
.meas tran vdout1_69ck28 FIND v(dout1_69) AT=145.025n

* CHECK dout1_70 Vdout1_70ck28 = 0.9 time = 145
.meas tran vdout1_70ck28 FIND v(dout1_70) AT=145.025n

* CHECK dout1_71 Vdout1_71ck28 = 0 time = 145
.meas tran vdout1_71ck28 FIND v(dout1_71) AT=145.025n

* CHECK dout1_72 Vdout1_72ck28 = 0.9 time = 145
.meas tran vdout1_72ck28 FIND v(dout1_72) AT=145.025n

* CHECK dout1_73 Vdout1_73ck28 = 0 time = 145
.meas tran vdout1_73ck28 FIND v(dout1_73) AT=145.025n

* CHECK dout1_74 Vdout1_74ck28 = 0.9 time = 145
.meas tran vdout1_74ck28 FIND v(dout1_74) AT=145.025n

* CHECK dout1_75 Vdout1_75ck28 = 0.9 time = 145
.meas tran vdout1_75ck28 FIND v(dout1_75) AT=145.025n

* CHECK dout1_76 Vdout1_76ck28 = 0 time = 145
.meas tran vdout1_76ck28 FIND v(dout1_76) AT=145.025n

* CHECK dout1_77 Vdout1_77ck28 = 0 time = 145
.meas tran vdout1_77ck28 FIND v(dout1_77) AT=145.025n

* CHECK dout1_78 Vdout1_78ck28 = 0.9 time = 145
.meas tran vdout1_78ck28 FIND v(dout1_78) AT=145.025n

* CHECK dout1_79 Vdout1_79ck28 = 0.9 time = 145
.meas tran vdout1_79ck28 FIND v(dout1_79) AT=145.025n

* CHECK dout1_80 Vdout1_80ck28 = 0.9 time = 145
.meas tran vdout1_80ck28 FIND v(dout1_80) AT=145.025n

* CHECK dout1_81 Vdout1_81ck28 = 0 time = 145
.meas tran vdout1_81ck28 FIND v(dout1_81) AT=145.025n

* CHECK dout1_82 Vdout1_82ck28 = 0 time = 145
.meas tran vdout1_82ck28 FIND v(dout1_82) AT=145.025n

* CHECK dout1_83 Vdout1_83ck28 = 0.9 time = 145
.meas tran vdout1_83ck28 FIND v(dout1_83) AT=145.025n

* CHECK dout1_84 Vdout1_84ck28 = 0.9 time = 145
.meas tran vdout1_84ck28 FIND v(dout1_84) AT=145.025n

* CHECK dout1_85 Vdout1_85ck28 = 0.9 time = 145
.meas tran vdout1_85ck28 FIND v(dout1_85) AT=145.025n

* CHECK dout1_86 Vdout1_86ck28 = 0 time = 145
.meas tran vdout1_86ck28 FIND v(dout1_86) AT=145.025n

* CHECK dout1_87 Vdout1_87ck28 = 0.9 time = 145
.meas tran vdout1_87ck28 FIND v(dout1_87) AT=145.025n

* CHECK dout1_88 Vdout1_88ck28 = 0.9 time = 145
.meas tran vdout1_88ck28 FIND v(dout1_88) AT=145.025n

* CHECK dout1_89 Vdout1_89ck28 = 0 time = 145
.meas tran vdout1_89ck28 FIND v(dout1_89) AT=145.025n

* CHECK dout1_90 Vdout1_90ck28 = 0.9 time = 145
.meas tran vdout1_90ck28 FIND v(dout1_90) AT=145.025n

* CHECK dout1_91 Vdout1_91ck28 = 0.9 time = 145
.meas tran vdout1_91ck28 FIND v(dout1_91) AT=145.025n

* CHECK dout1_92 Vdout1_92ck28 = 0 time = 145
.meas tran vdout1_92ck28 FIND v(dout1_92) AT=145.025n

* CHECK dout1_93 Vdout1_93ck28 = 0.9 time = 145
.meas tran vdout1_93ck28 FIND v(dout1_93) AT=145.025n

* CHECK dout1_94 Vdout1_94ck28 = 0.9 time = 145
.meas tran vdout1_94ck28 FIND v(dout1_94) AT=145.025n

* CHECK dout1_95 Vdout1_95ck28 = 0.9 time = 145
.meas tran vdout1_95ck28 FIND v(dout1_95) AT=145.025n

* CHECK dout1_96 Vdout1_96ck28 = 0 time = 145
.meas tran vdout1_96ck28 FIND v(dout1_96) AT=145.025n

* CHECK dout1_97 Vdout1_97ck28 = 0.9 time = 145
.meas tran vdout1_97ck28 FIND v(dout1_97) AT=145.025n

* CHECK dout1_98 Vdout1_98ck28 = 0 time = 145
.meas tran vdout1_98ck28 FIND v(dout1_98) AT=145.025n

* CHECK dout1_99 Vdout1_99ck28 = 0 time = 145
.meas tran vdout1_99ck28 FIND v(dout1_99) AT=145.025n

* CHECK dout1_100 Vdout1_100ck28 = 0.9 time = 145
.meas tran vdout1_100ck28 FIND v(dout1_100) AT=145.025n

* CHECK dout1_101 Vdout1_101ck28 = 0 time = 145
.meas tran vdout1_101ck28 FIND v(dout1_101) AT=145.025n

* CHECK dout1_102 Vdout1_102ck28 = 0 time = 145
.meas tran vdout1_102ck28 FIND v(dout1_102) AT=145.025n

* CHECK dout1_103 Vdout1_103ck28 = 0.9 time = 145
.meas tran vdout1_103ck28 FIND v(dout1_103) AT=145.025n

* CHECK dout1_104 Vdout1_104ck28 = 0 time = 145
.meas tran vdout1_104ck28 FIND v(dout1_104) AT=145.025n

* CHECK dout1_105 Vdout1_105ck28 = 0.9 time = 145
.meas tran vdout1_105ck28 FIND v(dout1_105) AT=145.025n

* CHECK dout1_106 Vdout1_106ck28 = 0.9 time = 145
.meas tran vdout1_106ck28 FIND v(dout1_106) AT=145.025n

* CHECK dout1_107 Vdout1_107ck28 = 0.9 time = 145
.meas tran vdout1_107ck28 FIND v(dout1_107) AT=145.025n

* CHECK dout1_108 Vdout1_108ck28 = 0.9 time = 145
.meas tran vdout1_108ck28 FIND v(dout1_108) AT=145.025n

* CHECK dout1_109 Vdout1_109ck28 = 0 time = 145
.meas tran vdout1_109ck28 FIND v(dout1_109) AT=145.025n

* CHECK dout1_110 Vdout1_110ck28 = 0 time = 145
.meas tran vdout1_110ck28 FIND v(dout1_110) AT=145.025n

* CHECK dout1_111 Vdout1_111ck28 = 0 time = 145
.meas tran vdout1_111ck28 FIND v(dout1_111) AT=145.025n

* CHECK dout1_112 Vdout1_112ck28 = 0.9 time = 145
.meas tran vdout1_112ck28 FIND v(dout1_112) AT=145.025n

* CHECK dout1_113 Vdout1_113ck28 = 0 time = 145
.meas tran vdout1_113ck28 FIND v(dout1_113) AT=145.025n

* CHECK dout1_114 Vdout1_114ck28 = 0.9 time = 145
.meas tran vdout1_114ck28 FIND v(dout1_114) AT=145.025n

* CHECK dout1_115 Vdout1_115ck28 = 0.9 time = 145
.meas tran vdout1_115ck28 FIND v(dout1_115) AT=145.025n

* CHECK dout1_116 Vdout1_116ck28 = 0 time = 145
.meas tran vdout1_116ck28 FIND v(dout1_116) AT=145.025n

* CHECK dout1_117 Vdout1_117ck28 = 0 time = 145
.meas tran vdout1_117ck28 FIND v(dout1_117) AT=145.025n

* CHECK dout1_118 Vdout1_118ck28 = 0 time = 145
.meas tran vdout1_118ck28 FIND v(dout1_118) AT=145.025n

* CHECK dout1_119 Vdout1_119ck28 = 0 time = 145
.meas tran vdout1_119ck28 FIND v(dout1_119) AT=145.025n

* CHECK dout1_0 Vdout1_0ck42 = 0.9 time = 215
.meas tran vdout1_0ck42 FIND v(dout1_0) AT=215.025n

* CHECK dout1_1 Vdout1_1ck42 = 0 time = 215
.meas tran vdout1_1ck42 FIND v(dout1_1) AT=215.025n

* CHECK dout1_2 Vdout1_2ck42 = 0 time = 215
.meas tran vdout1_2ck42 FIND v(dout1_2) AT=215.025n

* CHECK dout1_3 Vdout1_3ck42 = 0 time = 215
.meas tran vdout1_3ck42 FIND v(dout1_3) AT=215.025n

* CHECK dout1_4 Vdout1_4ck42 = 0 time = 215
.meas tran vdout1_4ck42 FIND v(dout1_4) AT=215.025n

* CHECK dout1_5 Vdout1_5ck42 = 0.9 time = 215
.meas tran vdout1_5ck42 FIND v(dout1_5) AT=215.025n

* CHECK dout1_6 Vdout1_6ck42 = 0 time = 215
.meas tran vdout1_6ck42 FIND v(dout1_6) AT=215.025n

* CHECK dout1_7 Vdout1_7ck42 = 0.9 time = 215
.meas tran vdout1_7ck42 FIND v(dout1_7) AT=215.025n

* CHECK dout1_8 Vdout1_8ck42 = 0 time = 215
.meas tran vdout1_8ck42 FIND v(dout1_8) AT=215.025n

* CHECK dout1_9 Vdout1_9ck42 = 0 time = 215
.meas tran vdout1_9ck42 FIND v(dout1_9) AT=215.025n

* CHECK dout1_10 Vdout1_10ck42 = 0.9 time = 215
.meas tran vdout1_10ck42 FIND v(dout1_10) AT=215.025n

* CHECK dout1_11 Vdout1_11ck42 = 0.9 time = 215
.meas tran vdout1_11ck42 FIND v(dout1_11) AT=215.025n

* CHECK dout1_12 Vdout1_12ck42 = 0.9 time = 215
.meas tran vdout1_12ck42 FIND v(dout1_12) AT=215.025n

* CHECK dout1_13 Vdout1_13ck42 = 0 time = 215
.meas tran vdout1_13ck42 FIND v(dout1_13) AT=215.025n

* CHECK dout1_14 Vdout1_14ck42 = 0.9 time = 215
.meas tran vdout1_14ck42 FIND v(dout1_14) AT=215.025n

* CHECK dout1_15 Vdout1_15ck42 = 0.9 time = 215
.meas tran vdout1_15ck42 FIND v(dout1_15) AT=215.025n

* CHECK dout1_16 Vdout1_16ck42 = 0 time = 215
.meas tran vdout1_16ck42 FIND v(dout1_16) AT=215.025n

* CHECK dout1_17 Vdout1_17ck42 = 0.9 time = 215
.meas tran vdout1_17ck42 FIND v(dout1_17) AT=215.025n

* CHECK dout1_18 Vdout1_18ck42 = 0.9 time = 215
.meas tran vdout1_18ck42 FIND v(dout1_18) AT=215.025n

* CHECK dout1_19 Vdout1_19ck42 = 0 time = 215
.meas tran vdout1_19ck42 FIND v(dout1_19) AT=215.025n

* CHECK dout1_20 Vdout1_20ck42 = 0.9 time = 215
.meas tran vdout1_20ck42 FIND v(dout1_20) AT=215.025n

* CHECK dout1_21 Vdout1_21ck42 = 0.9 time = 215
.meas tran vdout1_21ck42 FIND v(dout1_21) AT=215.025n

* CHECK dout1_22 Vdout1_22ck42 = 0.9 time = 215
.meas tran vdout1_22ck42 FIND v(dout1_22) AT=215.025n

* CHECK dout1_23 Vdout1_23ck42 = 0 time = 215
.meas tran vdout1_23ck42 FIND v(dout1_23) AT=215.025n

* CHECK dout1_24 Vdout1_24ck42 = 0 time = 215
.meas tran vdout1_24ck42 FIND v(dout1_24) AT=215.025n

* CHECK dout1_25 Vdout1_25ck42 = 0.9 time = 215
.meas tran vdout1_25ck42 FIND v(dout1_25) AT=215.025n

* CHECK dout1_26 Vdout1_26ck42 = 0 time = 215
.meas tran vdout1_26ck42 FIND v(dout1_26) AT=215.025n

* CHECK dout1_27 Vdout1_27ck42 = 0 time = 215
.meas tran vdout1_27ck42 FIND v(dout1_27) AT=215.025n

* CHECK dout1_28 Vdout1_28ck42 = 0.9 time = 215
.meas tran vdout1_28ck42 FIND v(dout1_28) AT=215.025n

* CHECK dout1_29 Vdout1_29ck42 = 0.9 time = 215
.meas tran vdout1_29ck42 FIND v(dout1_29) AT=215.025n

* CHECK dout1_30 Vdout1_30ck42 = 0.9 time = 215
.meas tran vdout1_30ck42 FIND v(dout1_30) AT=215.025n

* CHECK dout1_31 Vdout1_31ck42 = 0.9 time = 215
.meas tran vdout1_31ck42 FIND v(dout1_31) AT=215.025n

* CHECK dout1_32 Vdout1_32ck42 = 0.9 time = 215
.meas tran vdout1_32ck42 FIND v(dout1_32) AT=215.025n

* CHECK dout1_33 Vdout1_33ck42 = 0 time = 215
.meas tran vdout1_33ck42 FIND v(dout1_33) AT=215.025n

* CHECK dout1_34 Vdout1_34ck42 = 0.9 time = 215
.meas tran vdout1_34ck42 FIND v(dout1_34) AT=215.025n

* CHECK dout1_35 Vdout1_35ck42 = 0 time = 215
.meas tran vdout1_35ck42 FIND v(dout1_35) AT=215.025n

* CHECK dout1_36 Vdout1_36ck42 = 0 time = 215
.meas tran vdout1_36ck42 FIND v(dout1_36) AT=215.025n

* CHECK dout1_37 Vdout1_37ck42 = 0 time = 215
.meas tran vdout1_37ck42 FIND v(dout1_37) AT=215.025n

* CHECK dout1_38 Vdout1_38ck42 = 0 time = 215
.meas tran vdout1_38ck42 FIND v(dout1_38) AT=215.025n

* CHECK dout1_39 Vdout1_39ck42 = 0 time = 215
.meas tran vdout1_39ck42 FIND v(dout1_39) AT=215.025n

* CHECK dout1_40 Vdout1_40ck42 = 0.9 time = 215
.meas tran vdout1_40ck42 FIND v(dout1_40) AT=215.025n

* CHECK dout1_41 Vdout1_41ck42 = 0 time = 215
.meas tran vdout1_41ck42 FIND v(dout1_41) AT=215.025n

* CHECK dout1_42 Vdout1_42ck42 = 0.9 time = 215
.meas tran vdout1_42ck42 FIND v(dout1_42) AT=215.025n

* CHECK dout1_43 Vdout1_43ck42 = 0 time = 215
.meas tran vdout1_43ck42 FIND v(dout1_43) AT=215.025n

* CHECK dout1_44 Vdout1_44ck42 = 0 time = 215
.meas tran vdout1_44ck42 FIND v(dout1_44) AT=215.025n

* CHECK dout1_45 Vdout1_45ck42 = 0.9 time = 215
.meas tran vdout1_45ck42 FIND v(dout1_45) AT=215.025n

* CHECK dout1_46 Vdout1_46ck42 = 0 time = 215
.meas tran vdout1_46ck42 FIND v(dout1_46) AT=215.025n

* CHECK dout1_47 Vdout1_47ck42 = 0 time = 215
.meas tran vdout1_47ck42 FIND v(dout1_47) AT=215.025n

* CHECK dout1_48 Vdout1_48ck42 = 0 time = 215
.meas tran vdout1_48ck42 FIND v(dout1_48) AT=215.025n

* CHECK dout1_49 Vdout1_49ck42 = 0 time = 215
.meas tran vdout1_49ck42 FIND v(dout1_49) AT=215.025n

* CHECK dout1_50 Vdout1_50ck42 = 0 time = 215
.meas tran vdout1_50ck42 FIND v(dout1_50) AT=215.025n

* CHECK dout1_51 Vdout1_51ck42 = 0 time = 215
.meas tran vdout1_51ck42 FIND v(dout1_51) AT=215.025n

* CHECK dout1_52 Vdout1_52ck42 = 0.9 time = 215
.meas tran vdout1_52ck42 FIND v(dout1_52) AT=215.025n

* CHECK dout1_53 Vdout1_53ck42 = 0 time = 215
.meas tran vdout1_53ck42 FIND v(dout1_53) AT=215.025n

* CHECK dout1_54 Vdout1_54ck42 = 0.9 time = 215
.meas tran vdout1_54ck42 FIND v(dout1_54) AT=215.025n

* CHECK dout1_55 Vdout1_55ck42 = 0 time = 215
.meas tran vdout1_55ck42 FIND v(dout1_55) AT=215.025n

* CHECK dout1_56 Vdout1_56ck42 = 0 time = 215
.meas tran vdout1_56ck42 FIND v(dout1_56) AT=215.025n

* CHECK dout1_57 Vdout1_57ck42 = 0.9 time = 215
.meas tran vdout1_57ck42 FIND v(dout1_57) AT=215.025n

* CHECK dout1_58 Vdout1_58ck42 = 0.9 time = 215
.meas tran vdout1_58ck42 FIND v(dout1_58) AT=215.025n

* CHECK dout1_59 Vdout1_59ck42 = 0.9 time = 215
.meas tran vdout1_59ck42 FIND v(dout1_59) AT=215.025n

* CHECK dout1_60 Vdout1_60ck42 = 0.9 time = 215
.meas tran vdout1_60ck42 FIND v(dout1_60) AT=215.025n

* CHECK dout1_61 Vdout1_61ck42 = 0.9 time = 215
.meas tran vdout1_61ck42 FIND v(dout1_61) AT=215.025n

* CHECK dout1_62 Vdout1_62ck42 = 0 time = 215
.meas tran vdout1_62ck42 FIND v(dout1_62) AT=215.025n

* CHECK dout1_63 Vdout1_63ck42 = 0.9 time = 215
.meas tran vdout1_63ck42 FIND v(dout1_63) AT=215.025n

* CHECK dout1_64 Vdout1_64ck42 = 0 time = 215
.meas tran vdout1_64ck42 FIND v(dout1_64) AT=215.025n

* CHECK dout1_65 Vdout1_65ck42 = 0.9 time = 215
.meas tran vdout1_65ck42 FIND v(dout1_65) AT=215.025n

* CHECK dout1_66 Vdout1_66ck42 = 0 time = 215
.meas tran vdout1_66ck42 FIND v(dout1_66) AT=215.025n

* CHECK dout1_67 Vdout1_67ck42 = 0.9 time = 215
.meas tran vdout1_67ck42 FIND v(dout1_67) AT=215.025n

* CHECK dout1_68 Vdout1_68ck42 = 0.9 time = 215
.meas tran vdout1_68ck42 FIND v(dout1_68) AT=215.025n

* CHECK dout1_69 Vdout1_69ck42 = 0 time = 215
.meas tran vdout1_69ck42 FIND v(dout1_69) AT=215.025n

* CHECK dout1_70 Vdout1_70ck42 = 0 time = 215
.meas tran vdout1_70ck42 FIND v(dout1_70) AT=215.025n

* CHECK dout1_71 Vdout1_71ck42 = 0 time = 215
.meas tran vdout1_71ck42 FIND v(dout1_71) AT=215.025n

* CHECK dout1_72 Vdout1_72ck42 = 0.9 time = 215
.meas tran vdout1_72ck42 FIND v(dout1_72) AT=215.025n

* CHECK dout1_73 Vdout1_73ck42 = 0 time = 215
.meas tran vdout1_73ck42 FIND v(dout1_73) AT=215.025n

* CHECK dout1_74 Vdout1_74ck42 = 0 time = 215
.meas tran vdout1_74ck42 FIND v(dout1_74) AT=215.025n

* CHECK dout1_75 Vdout1_75ck42 = 0.9 time = 215
.meas tran vdout1_75ck42 FIND v(dout1_75) AT=215.025n

* CHECK dout1_76 Vdout1_76ck42 = 0.9 time = 215
.meas tran vdout1_76ck42 FIND v(dout1_76) AT=215.025n

* CHECK dout1_77 Vdout1_77ck42 = 0 time = 215
.meas tran vdout1_77ck42 FIND v(dout1_77) AT=215.025n

* CHECK dout1_78 Vdout1_78ck42 = 0.9 time = 215
.meas tran vdout1_78ck42 FIND v(dout1_78) AT=215.025n

* CHECK dout1_79 Vdout1_79ck42 = 0.9 time = 215
.meas tran vdout1_79ck42 FIND v(dout1_79) AT=215.025n

* CHECK dout1_80 Vdout1_80ck42 = 0 time = 215
.meas tran vdout1_80ck42 FIND v(dout1_80) AT=215.025n

* CHECK dout1_81 Vdout1_81ck42 = 0.9 time = 215
.meas tran vdout1_81ck42 FIND v(dout1_81) AT=215.025n

* CHECK dout1_82 Vdout1_82ck42 = 0 time = 215
.meas tran vdout1_82ck42 FIND v(dout1_82) AT=215.025n

* CHECK dout1_83 Vdout1_83ck42 = 0 time = 215
.meas tran vdout1_83ck42 FIND v(dout1_83) AT=215.025n

* CHECK dout1_84 Vdout1_84ck42 = 0 time = 215
.meas tran vdout1_84ck42 FIND v(dout1_84) AT=215.025n

* CHECK dout1_85 Vdout1_85ck42 = 0.9 time = 215
.meas tran vdout1_85ck42 FIND v(dout1_85) AT=215.025n

* CHECK dout1_86 Vdout1_86ck42 = 0 time = 215
.meas tran vdout1_86ck42 FIND v(dout1_86) AT=215.025n

* CHECK dout1_87 Vdout1_87ck42 = 0 time = 215
.meas tran vdout1_87ck42 FIND v(dout1_87) AT=215.025n

* CHECK dout1_88 Vdout1_88ck42 = 0 time = 215
.meas tran vdout1_88ck42 FIND v(dout1_88) AT=215.025n

* CHECK dout1_89 Vdout1_89ck42 = 0.9 time = 215
.meas tran vdout1_89ck42 FIND v(dout1_89) AT=215.025n

* CHECK dout1_90 Vdout1_90ck42 = 0 time = 215
.meas tran vdout1_90ck42 FIND v(dout1_90) AT=215.025n

* CHECK dout1_91 Vdout1_91ck42 = 0.9 time = 215
.meas tran vdout1_91ck42 FIND v(dout1_91) AT=215.025n

* CHECK dout1_92 Vdout1_92ck42 = 0.9 time = 215
.meas tran vdout1_92ck42 FIND v(dout1_92) AT=215.025n

* CHECK dout1_93 Vdout1_93ck42 = 0 time = 215
.meas tran vdout1_93ck42 FIND v(dout1_93) AT=215.025n

* CHECK dout1_94 Vdout1_94ck42 = 0.9 time = 215
.meas tran vdout1_94ck42 FIND v(dout1_94) AT=215.025n

* CHECK dout1_95 Vdout1_95ck42 = 0.9 time = 215
.meas tran vdout1_95ck42 FIND v(dout1_95) AT=215.025n

* CHECK dout1_96 Vdout1_96ck42 = 0.9 time = 215
.meas tran vdout1_96ck42 FIND v(dout1_96) AT=215.025n

* CHECK dout1_97 Vdout1_97ck42 = 0.9 time = 215
.meas tran vdout1_97ck42 FIND v(dout1_97) AT=215.025n

* CHECK dout1_98 Vdout1_98ck42 = 0 time = 215
.meas tran vdout1_98ck42 FIND v(dout1_98) AT=215.025n

* CHECK dout1_99 Vdout1_99ck42 = 0 time = 215
.meas tran vdout1_99ck42 FIND v(dout1_99) AT=215.025n

* CHECK dout1_100 Vdout1_100ck42 = 0.9 time = 215
.meas tran vdout1_100ck42 FIND v(dout1_100) AT=215.025n

* CHECK dout1_101 Vdout1_101ck42 = 0.9 time = 215
.meas tran vdout1_101ck42 FIND v(dout1_101) AT=215.025n

* CHECK dout1_102 Vdout1_102ck42 = 0 time = 215
.meas tran vdout1_102ck42 FIND v(dout1_102) AT=215.025n

* CHECK dout1_103 Vdout1_103ck42 = 0 time = 215
.meas tran vdout1_103ck42 FIND v(dout1_103) AT=215.025n

* CHECK dout1_104 Vdout1_104ck42 = 0.9 time = 215
.meas tran vdout1_104ck42 FIND v(dout1_104) AT=215.025n

* CHECK dout1_105 Vdout1_105ck42 = 0.9 time = 215
.meas tran vdout1_105ck42 FIND v(dout1_105) AT=215.025n

* CHECK dout1_106 Vdout1_106ck42 = 0.9 time = 215
.meas tran vdout1_106ck42 FIND v(dout1_106) AT=215.025n

* CHECK dout1_107 Vdout1_107ck42 = 0 time = 215
.meas tran vdout1_107ck42 FIND v(dout1_107) AT=215.025n

* CHECK dout1_108 Vdout1_108ck42 = 0 time = 215
.meas tran vdout1_108ck42 FIND v(dout1_108) AT=215.025n

* CHECK dout1_109 Vdout1_109ck42 = 0.9 time = 215
.meas tran vdout1_109ck42 FIND v(dout1_109) AT=215.025n

* CHECK dout1_110 Vdout1_110ck42 = 0 time = 215
.meas tran vdout1_110ck42 FIND v(dout1_110) AT=215.025n

* CHECK dout1_111 Vdout1_111ck42 = 0 time = 215
.meas tran vdout1_111ck42 FIND v(dout1_111) AT=215.025n

* CHECK dout1_112 Vdout1_112ck42 = 0.9 time = 215
.meas tran vdout1_112ck42 FIND v(dout1_112) AT=215.025n

* CHECK dout1_113 Vdout1_113ck42 = 0 time = 215
.meas tran vdout1_113ck42 FIND v(dout1_113) AT=215.025n

* CHECK dout1_114 Vdout1_114ck42 = 0.9 time = 215
.meas tran vdout1_114ck42 FIND v(dout1_114) AT=215.025n

* CHECK dout1_115 Vdout1_115ck42 = 0 time = 215
.meas tran vdout1_115ck42 FIND v(dout1_115) AT=215.025n

* CHECK dout1_116 Vdout1_116ck42 = 0 time = 215
.meas tran vdout1_116ck42 FIND v(dout1_116) AT=215.025n

* CHECK dout1_117 Vdout1_117ck42 = 0.9 time = 215
.meas tran vdout1_117ck42 FIND v(dout1_117) AT=215.025n

* CHECK dout1_118 Vdout1_118ck42 = 0.9 time = 215
.meas tran vdout1_118ck42 FIND v(dout1_118) AT=215.025n

* CHECK dout1_119 Vdout1_119ck42 = 0 time = 215
.meas tran vdout1_119ck42 FIND v(dout1_119) AT=215.025n

* CHECK dout1_0 Vdout1_0ck45 = 0.9 time = 230
.meas tran vdout1_0ck45 FIND v(dout1_0) AT=230.025n

* CHECK dout1_1 Vdout1_1ck45 = 0 time = 230
.meas tran vdout1_1ck45 FIND v(dout1_1) AT=230.025n

* CHECK dout1_2 Vdout1_2ck45 = 0 time = 230
.meas tran vdout1_2ck45 FIND v(dout1_2) AT=230.025n

* CHECK dout1_3 Vdout1_3ck45 = 0 time = 230
.meas tran vdout1_3ck45 FIND v(dout1_3) AT=230.025n

* CHECK dout1_4 Vdout1_4ck45 = 0 time = 230
.meas tran vdout1_4ck45 FIND v(dout1_4) AT=230.025n

* CHECK dout1_5 Vdout1_5ck45 = 0.9 time = 230
.meas tran vdout1_5ck45 FIND v(dout1_5) AT=230.025n

* CHECK dout1_6 Vdout1_6ck45 = 0 time = 230
.meas tran vdout1_6ck45 FIND v(dout1_6) AT=230.025n

* CHECK dout1_7 Vdout1_7ck45 = 0.9 time = 230
.meas tran vdout1_7ck45 FIND v(dout1_7) AT=230.025n

* CHECK dout1_8 Vdout1_8ck45 = 0 time = 230
.meas tran vdout1_8ck45 FIND v(dout1_8) AT=230.025n

* CHECK dout1_9 Vdout1_9ck45 = 0 time = 230
.meas tran vdout1_9ck45 FIND v(dout1_9) AT=230.025n

* CHECK dout1_10 Vdout1_10ck45 = 0.9 time = 230
.meas tran vdout1_10ck45 FIND v(dout1_10) AT=230.025n

* CHECK dout1_11 Vdout1_11ck45 = 0.9 time = 230
.meas tran vdout1_11ck45 FIND v(dout1_11) AT=230.025n

* CHECK dout1_12 Vdout1_12ck45 = 0.9 time = 230
.meas tran vdout1_12ck45 FIND v(dout1_12) AT=230.025n

* CHECK dout1_13 Vdout1_13ck45 = 0 time = 230
.meas tran vdout1_13ck45 FIND v(dout1_13) AT=230.025n

* CHECK dout1_14 Vdout1_14ck45 = 0.9 time = 230
.meas tran vdout1_14ck45 FIND v(dout1_14) AT=230.025n

* CHECK dout1_15 Vdout1_15ck45 = 0.9 time = 230
.meas tran vdout1_15ck45 FIND v(dout1_15) AT=230.025n

* CHECK dout1_16 Vdout1_16ck45 = 0 time = 230
.meas tran vdout1_16ck45 FIND v(dout1_16) AT=230.025n

* CHECK dout1_17 Vdout1_17ck45 = 0.9 time = 230
.meas tran vdout1_17ck45 FIND v(dout1_17) AT=230.025n

* CHECK dout1_18 Vdout1_18ck45 = 0.9 time = 230
.meas tran vdout1_18ck45 FIND v(dout1_18) AT=230.025n

* CHECK dout1_19 Vdout1_19ck45 = 0 time = 230
.meas tran vdout1_19ck45 FIND v(dout1_19) AT=230.025n

* CHECK dout1_20 Vdout1_20ck45 = 0.9 time = 230
.meas tran vdout1_20ck45 FIND v(dout1_20) AT=230.025n

* CHECK dout1_21 Vdout1_21ck45 = 0.9 time = 230
.meas tran vdout1_21ck45 FIND v(dout1_21) AT=230.025n

* CHECK dout1_22 Vdout1_22ck45 = 0.9 time = 230
.meas tran vdout1_22ck45 FIND v(dout1_22) AT=230.025n

* CHECK dout1_23 Vdout1_23ck45 = 0 time = 230
.meas tran vdout1_23ck45 FIND v(dout1_23) AT=230.025n

* CHECK dout1_24 Vdout1_24ck45 = 0 time = 230
.meas tran vdout1_24ck45 FIND v(dout1_24) AT=230.025n

* CHECK dout1_25 Vdout1_25ck45 = 0.9 time = 230
.meas tran vdout1_25ck45 FIND v(dout1_25) AT=230.025n

* CHECK dout1_26 Vdout1_26ck45 = 0 time = 230
.meas tran vdout1_26ck45 FIND v(dout1_26) AT=230.025n

* CHECK dout1_27 Vdout1_27ck45 = 0 time = 230
.meas tran vdout1_27ck45 FIND v(dout1_27) AT=230.025n

* CHECK dout1_28 Vdout1_28ck45 = 0.9 time = 230
.meas tran vdout1_28ck45 FIND v(dout1_28) AT=230.025n

* CHECK dout1_29 Vdout1_29ck45 = 0.9 time = 230
.meas tran vdout1_29ck45 FIND v(dout1_29) AT=230.025n

* CHECK dout1_30 Vdout1_30ck45 = 0.9 time = 230
.meas tran vdout1_30ck45 FIND v(dout1_30) AT=230.025n

* CHECK dout1_31 Vdout1_31ck45 = 0.9 time = 230
.meas tran vdout1_31ck45 FIND v(dout1_31) AT=230.025n

* CHECK dout1_32 Vdout1_32ck45 = 0.9 time = 230
.meas tran vdout1_32ck45 FIND v(dout1_32) AT=230.025n

* CHECK dout1_33 Vdout1_33ck45 = 0 time = 230
.meas tran vdout1_33ck45 FIND v(dout1_33) AT=230.025n

* CHECK dout1_34 Vdout1_34ck45 = 0.9 time = 230
.meas tran vdout1_34ck45 FIND v(dout1_34) AT=230.025n

* CHECK dout1_35 Vdout1_35ck45 = 0 time = 230
.meas tran vdout1_35ck45 FIND v(dout1_35) AT=230.025n

* CHECK dout1_36 Vdout1_36ck45 = 0 time = 230
.meas tran vdout1_36ck45 FIND v(dout1_36) AT=230.025n

* CHECK dout1_37 Vdout1_37ck45 = 0 time = 230
.meas tran vdout1_37ck45 FIND v(dout1_37) AT=230.025n

* CHECK dout1_38 Vdout1_38ck45 = 0 time = 230
.meas tran vdout1_38ck45 FIND v(dout1_38) AT=230.025n

* CHECK dout1_39 Vdout1_39ck45 = 0 time = 230
.meas tran vdout1_39ck45 FIND v(dout1_39) AT=230.025n

* CHECK dout1_40 Vdout1_40ck45 = 0.9 time = 230
.meas tran vdout1_40ck45 FIND v(dout1_40) AT=230.025n

* CHECK dout1_41 Vdout1_41ck45 = 0 time = 230
.meas tran vdout1_41ck45 FIND v(dout1_41) AT=230.025n

* CHECK dout1_42 Vdout1_42ck45 = 0.9 time = 230
.meas tran vdout1_42ck45 FIND v(dout1_42) AT=230.025n

* CHECK dout1_43 Vdout1_43ck45 = 0 time = 230
.meas tran vdout1_43ck45 FIND v(dout1_43) AT=230.025n

* CHECK dout1_44 Vdout1_44ck45 = 0 time = 230
.meas tran vdout1_44ck45 FIND v(dout1_44) AT=230.025n

* CHECK dout1_45 Vdout1_45ck45 = 0.9 time = 230
.meas tran vdout1_45ck45 FIND v(dout1_45) AT=230.025n

* CHECK dout1_46 Vdout1_46ck45 = 0 time = 230
.meas tran vdout1_46ck45 FIND v(dout1_46) AT=230.025n

* CHECK dout1_47 Vdout1_47ck45 = 0 time = 230
.meas tran vdout1_47ck45 FIND v(dout1_47) AT=230.025n

* CHECK dout1_48 Vdout1_48ck45 = 0 time = 230
.meas tran vdout1_48ck45 FIND v(dout1_48) AT=230.025n

* CHECK dout1_49 Vdout1_49ck45 = 0 time = 230
.meas tran vdout1_49ck45 FIND v(dout1_49) AT=230.025n

* CHECK dout1_50 Vdout1_50ck45 = 0 time = 230
.meas tran vdout1_50ck45 FIND v(dout1_50) AT=230.025n

* CHECK dout1_51 Vdout1_51ck45 = 0 time = 230
.meas tran vdout1_51ck45 FIND v(dout1_51) AT=230.025n

* CHECK dout1_52 Vdout1_52ck45 = 0.9 time = 230
.meas tran vdout1_52ck45 FIND v(dout1_52) AT=230.025n

* CHECK dout1_53 Vdout1_53ck45 = 0 time = 230
.meas tran vdout1_53ck45 FIND v(dout1_53) AT=230.025n

* CHECK dout1_54 Vdout1_54ck45 = 0.9 time = 230
.meas tran vdout1_54ck45 FIND v(dout1_54) AT=230.025n

* CHECK dout1_55 Vdout1_55ck45 = 0 time = 230
.meas tran vdout1_55ck45 FIND v(dout1_55) AT=230.025n

* CHECK dout1_56 Vdout1_56ck45 = 0 time = 230
.meas tran vdout1_56ck45 FIND v(dout1_56) AT=230.025n

* CHECK dout1_57 Vdout1_57ck45 = 0.9 time = 230
.meas tran vdout1_57ck45 FIND v(dout1_57) AT=230.025n

* CHECK dout1_58 Vdout1_58ck45 = 0.9 time = 230
.meas tran vdout1_58ck45 FIND v(dout1_58) AT=230.025n

* CHECK dout1_59 Vdout1_59ck45 = 0.9 time = 230
.meas tran vdout1_59ck45 FIND v(dout1_59) AT=230.025n

* CHECK dout1_60 Vdout1_60ck45 = 0.9 time = 230
.meas tran vdout1_60ck45 FIND v(dout1_60) AT=230.025n

* CHECK dout1_61 Vdout1_61ck45 = 0.9 time = 230
.meas tran vdout1_61ck45 FIND v(dout1_61) AT=230.025n

* CHECK dout1_62 Vdout1_62ck45 = 0 time = 230
.meas tran vdout1_62ck45 FIND v(dout1_62) AT=230.025n

* CHECK dout1_63 Vdout1_63ck45 = 0.9 time = 230
.meas tran vdout1_63ck45 FIND v(dout1_63) AT=230.025n

* CHECK dout1_64 Vdout1_64ck45 = 0 time = 230
.meas tran vdout1_64ck45 FIND v(dout1_64) AT=230.025n

* CHECK dout1_65 Vdout1_65ck45 = 0.9 time = 230
.meas tran vdout1_65ck45 FIND v(dout1_65) AT=230.025n

* CHECK dout1_66 Vdout1_66ck45 = 0 time = 230
.meas tran vdout1_66ck45 FIND v(dout1_66) AT=230.025n

* CHECK dout1_67 Vdout1_67ck45 = 0.9 time = 230
.meas tran vdout1_67ck45 FIND v(dout1_67) AT=230.025n

* CHECK dout1_68 Vdout1_68ck45 = 0.9 time = 230
.meas tran vdout1_68ck45 FIND v(dout1_68) AT=230.025n

* CHECK dout1_69 Vdout1_69ck45 = 0 time = 230
.meas tran vdout1_69ck45 FIND v(dout1_69) AT=230.025n

* CHECK dout1_70 Vdout1_70ck45 = 0 time = 230
.meas tran vdout1_70ck45 FIND v(dout1_70) AT=230.025n

* CHECK dout1_71 Vdout1_71ck45 = 0 time = 230
.meas tran vdout1_71ck45 FIND v(dout1_71) AT=230.025n

* CHECK dout1_72 Vdout1_72ck45 = 0.9 time = 230
.meas tran vdout1_72ck45 FIND v(dout1_72) AT=230.025n

* CHECK dout1_73 Vdout1_73ck45 = 0 time = 230
.meas tran vdout1_73ck45 FIND v(dout1_73) AT=230.025n

* CHECK dout1_74 Vdout1_74ck45 = 0 time = 230
.meas tran vdout1_74ck45 FIND v(dout1_74) AT=230.025n

* CHECK dout1_75 Vdout1_75ck45 = 0.9 time = 230
.meas tran vdout1_75ck45 FIND v(dout1_75) AT=230.025n

* CHECK dout1_76 Vdout1_76ck45 = 0.9 time = 230
.meas tran vdout1_76ck45 FIND v(dout1_76) AT=230.025n

* CHECK dout1_77 Vdout1_77ck45 = 0 time = 230
.meas tran vdout1_77ck45 FIND v(dout1_77) AT=230.025n

* CHECK dout1_78 Vdout1_78ck45 = 0.9 time = 230
.meas tran vdout1_78ck45 FIND v(dout1_78) AT=230.025n

* CHECK dout1_79 Vdout1_79ck45 = 0.9 time = 230
.meas tran vdout1_79ck45 FIND v(dout1_79) AT=230.025n

* CHECK dout1_80 Vdout1_80ck45 = 0 time = 230
.meas tran vdout1_80ck45 FIND v(dout1_80) AT=230.025n

* CHECK dout1_81 Vdout1_81ck45 = 0.9 time = 230
.meas tran vdout1_81ck45 FIND v(dout1_81) AT=230.025n

* CHECK dout1_82 Vdout1_82ck45 = 0 time = 230
.meas tran vdout1_82ck45 FIND v(dout1_82) AT=230.025n

* CHECK dout1_83 Vdout1_83ck45 = 0 time = 230
.meas tran vdout1_83ck45 FIND v(dout1_83) AT=230.025n

* CHECK dout1_84 Vdout1_84ck45 = 0 time = 230
.meas tran vdout1_84ck45 FIND v(dout1_84) AT=230.025n

* CHECK dout1_85 Vdout1_85ck45 = 0.9 time = 230
.meas tran vdout1_85ck45 FIND v(dout1_85) AT=230.025n

* CHECK dout1_86 Vdout1_86ck45 = 0 time = 230
.meas tran vdout1_86ck45 FIND v(dout1_86) AT=230.025n

* CHECK dout1_87 Vdout1_87ck45 = 0 time = 230
.meas tran vdout1_87ck45 FIND v(dout1_87) AT=230.025n

* CHECK dout1_88 Vdout1_88ck45 = 0 time = 230
.meas tran vdout1_88ck45 FIND v(dout1_88) AT=230.025n

* CHECK dout1_89 Vdout1_89ck45 = 0.9 time = 230
.meas tran vdout1_89ck45 FIND v(dout1_89) AT=230.025n

* CHECK dout1_90 Vdout1_90ck45 = 0 time = 230
.meas tran vdout1_90ck45 FIND v(dout1_90) AT=230.025n

* CHECK dout1_91 Vdout1_91ck45 = 0.9 time = 230
.meas tran vdout1_91ck45 FIND v(dout1_91) AT=230.025n

* CHECK dout1_92 Vdout1_92ck45 = 0.9 time = 230
.meas tran vdout1_92ck45 FIND v(dout1_92) AT=230.025n

* CHECK dout1_93 Vdout1_93ck45 = 0 time = 230
.meas tran vdout1_93ck45 FIND v(dout1_93) AT=230.025n

* CHECK dout1_94 Vdout1_94ck45 = 0.9 time = 230
.meas tran vdout1_94ck45 FIND v(dout1_94) AT=230.025n

* CHECK dout1_95 Vdout1_95ck45 = 0.9 time = 230
.meas tran vdout1_95ck45 FIND v(dout1_95) AT=230.025n

* CHECK dout1_96 Vdout1_96ck45 = 0.9 time = 230
.meas tran vdout1_96ck45 FIND v(dout1_96) AT=230.025n

* CHECK dout1_97 Vdout1_97ck45 = 0.9 time = 230
.meas tran vdout1_97ck45 FIND v(dout1_97) AT=230.025n

* CHECK dout1_98 Vdout1_98ck45 = 0 time = 230
.meas tran vdout1_98ck45 FIND v(dout1_98) AT=230.025n

* CHECK dout1_99 Vdout1_99ck45 = 0 time = 230
.meas tran vdout1_99ck45 FIND v(dout1_99) AT=230.025n

* CHECK dout1_100 Vdout1_100ck45 = 0.9 time = 230
.meas tran vdout1_100ck45 FIND v(dout1_100) AT=230.025n

* CHECK dout1_101 Vdout1_101ck45 = 0.9 time = 230
.meas tran vdout1_101ck45 FIND v(dout1_101) AT=230.025n

* CHECK dout1_102 Vdout1_102ck45 = 0 time = 230
.meas tran vdout1_102ck45 FIND v(dout1_102) AT=230.025n

* CHECK dout1_103 Vdout1_103ck45 = 0 time = 230
.meas tran vdout1_103ck45 FIND v(dout1_103) AT=230.025n

* CHECK dout1_104 Vdout1_104ck45 = 0.9 time = 230
.meas tran vdout1_104ck45 FIND v(dout1_104) AT=230.025n

* CHECK dout1_105 Vdout1_105ck45 = 0.9 time = 230
.meas tran vdout1_105ck45 FIND v(dout1_105) AT=230.025n

* CHECK dout1_106 Vdout1_106ck45 = 0.9 time = 230
.meas tran vdout1_106ck45 FIND v(dout1_106) AT=230.025n

* CHECK dout1_107 Vdout1_107ck45 = 0 time = 230
.meas tran vdout1_107ck45 FIND v(dout1_107) AT=230.025n

* CHECK dout1_108 Vdout1_108ck45 = 0 time = 230
.meas tran vdout1_108ck45 FIND v(dout1_108) AT=230.025n

* CHECK dout1_109 Vdout1_109ck45 = 0.9 time = 230
.meas tran vdout1_109ck45 FIND v(dout1_109) AT=230.025n

* CHECK dout1_110 Vdout1_110ck45 = 0 time = 230
.meas tran vdout1_110ck45 FIND v(dout1_110) AT=230.025n

* CHECK dout1_111 Vdout1_111ck45 = 0 time = 230
.meas tran vdout1_111ck45 FIND v(dout1_111) AT=230.025n

* CHECK dout1_112 Vdout1_112ck45 = 0.9 time = 230
.meas tran vdout1_112ck45 FIND v(dout1_112) AT=230.025n

* CHECK dout1_113 Vdout1_113ck45 = 0 time = 230
.meas tran vdout1_113ck45 FIND v(dout1_113) AT=230.025n

* CHECK dout1_114 Vdout1_114ck45 = 0.9 time = 230
.meas tran vdout1_114ck45 FIND v(dout1_114) AT=230.025n

* CHECK dout1_115 Vdout1_115ck45 = 0 time = 230
.meas tran vdout1_115ck45 FIND v(dout1_115) AT=230.025n

* CHECK dout1_116 Vdout1_116ck45 = 0 time = 230
.meas tran vdout1_116ck45 FIND v(dout1_116) AT=230.025n

* CHECK dout1_117 Vdout1_117ck45 = 0.9 time = 230
.meas tran vdout1_117ck45 FIND v(dout1_117) AT=230.025n

* CHECK dout1_118 Vdout1_118ck45 = 0.9 time = 230
.meas tran vdout1_118ck45 FIND v(dout1_118) AT=230.025n

* CHECK dout1_119 Vdout1_119ck45 = 0 time = 230
.meas tran vdout1_119ck45 FIND v(dout1_119) AT=230.025n

* CHECK dout1_0 Vdout1_0ck46 = 0 time = 235
.meas tran vdout1_0ck46 FIND v(dout1_0) AT=235.025n

* CHECK dout1_1 Vdout1_1ck46 = 0 time = 235
.meas tran vdout1_1ck46 FIND v(dout1_1) AT=235.025n

* CHECK dout1_2 Vdout1_2ck46 = 0 time = 235
.meas tran vdout1_2ck46 FIND v(dout1_2) AT=235.025n

* CHECK dout1_3 Vdout1_3ck46 = 0 time = 235
.meas tran vdout1_3ck46 FIND v(dout1_3) AT=235.025n

* CHECK dout1_4 Vdout1_4ck46 = 0 time = 235
.meas tran vdout1_4ck46 FIND v(dout1_4) AT=235.025n

* CHECK dout1_5 Vdout1_5ck46 = 0 time = 235
.meas tran vdout1_5ck46 FIND v(dout1_5) AT=235.025n

* CHECK dout1_6 Vdout1_6ck46 = 0.9 time = 235
.meas tran vdout1_6ck46 FIND v(dout1_6) AT=235.025n

* CHECK dout1_7 Vdout1_7ck46 = 0 time = 235
.meas tran vdout1_7ck46 FIND v(dout1_7) AT=235.025n

* CHECK dout1_8 Vdout1_8ck46 = 0.9 time = 235
.meas tran vdout1_8ck46 FIND v(dout1_8) AT=235.025n

* CHECK dout1_9 Vdout1_9ck46 = 0.9 time = 235
.meas tran vdout1_9ck46 FIND v(dout1_9) AT=235.025n

* CHECK dout1_10 Vdout1_10ck46 = 0.9 time = 235
.meas tran vdout1_10ck46 FIND v(dout1_10) AT=235.025n

* CHECK dout1_11 Vdout1_11ck46 = 0.9 time = 235
.meas tran vdout1_11ck46 FIND v(dout1_11) AT=235.025n

* CHECK dout1_12 Vdout1_12ck46 = 0.9 time = 235
.meas tran vdout1_12ck46 FIND v(dout1_12) AT=235.025n

* CHECK dout1_13 Vdout1_13ck46 = 0.9 time = 235
.meas tran vdout1_13ck46 FIND v(dout1_13) AT=235.025n

* CHECK dout1_14 Vdout1_14ck46 = 0.9 time = 235
.meas tran vdout1_14ck46 FIND v(dout1_14) AT=235.025n

* CHECK dout1_15 Vdout1_15ck46 = 0 time = 235
.meas tran vdout1_15ck46 FIND v(dout1_15) AT=235.025n

* CHECK dout1_16 Vdout1_16ck46 = 0 time = 235
.meas tran vdout1_16ck46 FIND v(dout1_16) AT=235.025n

* CHECK dout1_17 Vdout1_17ck46 = 0 time = 235
.meas tran vdout1_17ck46 FIND v(dout1_17) AT=235.025n

* CHECK dout1_18 Vdout1_18ck46 = 0 time = 235
.meas tran vdout1_18ck46 FIND v(dout1_18) AT=235.025n

* CHECK dout1_19 Vdout1_19ck46 = 0.9 time = 235
.meas tran vdout1_19ck46 FIND v(dout1_19) AT=235.025n

* CHECK dout1_20 Vdout1_20ck46 = 0.9 time = 235
.meas tran vdout1_20ck46 FIND v(dout1_20) AT=235.025n

* CHECK dout1_21 Vdout1_21ck46 = 0 time = 235
.meas tran vdout1_21ck46 FIND v(dout1_21) AT=235.025n

* CHECK dout1_22 Vdout1_22ck46 = 0 time = 235
.meas tran vdout1_22ck46 FIND v(dout1_22) AT=235.025n

* CHECK dout1_23 Vdout1_23ck46 = 0 time = 235
.meas tran vdout1_23ck46 FIND v(dout1_23) AT=235.025n

* CHECK dout1_24 Vdout1_24ck46 = 0.9 time = 235
.meas tran vdout1_24ck46 FIND v(dout1_24) AT=235.025n

* CHECK dout1_25 Vdout1_25ck46 = 0.9 time = 235
.meas tran vdout1_25ck46 FIND v(dout1_25) AT=235.025n

* CHECK dout1_26 Vdout1_26ck46 = 0.9 time = 235
.meas tran vdout1_26ck46 FIND v(dout1_26) AT=235.025n

* CHECK dout1_27 Vdout1_27ck46 = 0.9 time = 235
.meas tran vdout1_27ck46 FIND v(dout1_27) AT=235.025n

* CHECK dout1_28 Vdout1_28ck46 = 0 time = 235
.meas tran vdout1_28ck46 FIND v(dout1_28) AT=235.025n

* CHECK dout1_29 Vdout1_29ck46 = 0.9 time = 235
.meas tran vdout1_29ck46 FIND v(dout1_29) AT=235.025n

* CHECK dout1_30 Vdout1_30ck46 = 0 time = 235
.meas tran vdout1_30ck46 FIND v(dout1_30) AT=235.025n

* CHECK dout1_31 Vdout1_31ck46 = 0 time = 235
.meas tran vdout1_31ck46 FIND v(dout1_31) AT=235.025n

* CHECK dout1_32 Vdout1_32ck46 = 0 time = 235
.meas tran vdout1_32ck46 FIND v(dout1_32) AT=235.025n

* CHECK dout1_33 Vdout1_33ck46 = 0 time = 235
.meas tran vdout1_33ck46 FIND v(dout1_33) AT=235.025n

* CHECK dout1_34 Vdout1_34ck46 = 0 time = 235
.meas tran vdout1_34ck46 FIND v(dout1_34) AT=235.025n

* CHECK dout1_35 Vdout1_35ck46 = 0 time = 235
.meas tran vdout1_35ck46 FIND v(dout1_35) AT=235.025n

* CHECK dout1_36 Vdout1_36ck46 = 0 time = 235
.meas tran vdout1_36ck46 FIND v(dout1_36) AT=235.025n

* CHECK dout1_37 Vdout1_37ck46 = 0 time = 235
.meas tran vdout1_37ck46 FIND v(dout1_37) AT=235.025n

* CHECK dout1_38 Vdout1_38ck46 = 0 time = 235
.meas tran vdout1_38ck46 FIND v(dout1_38) AT=235.025n

* CHECK dout1_39 Vdout1_39ck46 = 0.9 time = 235
.meas tran vdout1_39ck46 FIND v(dout1_39) AT=235.025n

* CHECK dout1_40 Vdout1_40ck46 = 0 time = 235
.meas tran vdout1_40ck46 FIND v(dout1_40) AT=235.025n

* CHECK dout1_41 Vdout1_41ck46 = 0 time = 235
.meas tran vdout1_41ck46 FIND v(dout1_41) AT=235.025n

* CHECK dout1_42 Vdout1_42ck46 = 0.9 time = 235
.meas tran vdout1_42ck46 FIND v(dout1_42) AT=235.025n

* CHECK dout1_43 Vdout1_43ck46 = 0.9 time = 235
.meas tran vdout1_43ck46 FIND v(dout1_43) AT=235.025n

* CHECK dout1_44 Vdout1_44ck46 = 0.9 time = 235
.meas tran vdout1_44ck46 FIND v(dout1_44) AT=235.025n

* CHECK dout1_45 Vdout1_45ck46 = 0 time = 235
.meas tran vdout1_45ck46 FIND v(dout1_45) AT=235.025n

* CHECK dout1_46 Vdout1_46ck46 = 0.9 time = 235
.meas tran vdout1_46ck46 FIND v(dout1_46) AT=235.025n

* CHECK dout1_47 Vdout1_47ck46 = 0.9 time = 235
.meas tran vdout1_47ck46 FIND v(dout1_47) AT=235.025n

* CHECK dout1_48 Vdout1_48ck46 = 0.9 time = 235
.meas tran vdout1_48ck46 FIND v(dout1_48) AT=235.025n

* CHECK dout1_49 Vdout1_49ck46 = 0.9 time = 235
.meas tran vdout1_49ck46 FIND v(dout1_49) AT=235.025n

* CHECK dout1_50 Vdout1_50ck46 = 0.9 time = 235
.meas tran vdout1_50ck46 FIND v(dout1_50) AT=235.025n

* CHECK dout1_51 Vdout1_51ck46 = 0.9 time = 235
.meas tran vdout1_51ck46 FIND v(dout1_51) AT=235.025n

* CHECK dout1_52 Vdout1_52ck46 = 0.9 time = 235
.meas tran vdout1_52ck46 FIND v(dout1_52) AT=235.025n

* CHECK dout1_53 Vdout1_53ck46 = 0 time = 235
.meas tran vdout1_53ck46 FIND v(dout1_53) AT=235.025n

* CHECK dout1_54 Vdout1_54ck46 = 0 time = 235
.meas tran vdout1_54ck46 FIND v(dout1_54) AT=235.025n

* CHECK dout1_55 Vdout1_55ck46 = 0 time = 235
.meas tran vdout1_55ck46 FIND v(dout1_55) AT=235.025n

* CHECK dout1_56 Vdout1_56ck46 = 0 time = 235
.meas tran vdout1_56ck46 FIND v(dout1_56) AT=235.025n

* CHECK dout1_57 Vdout1_57ck46 = 0.9 time = 235
.meas tran vdout1_57ck46 FIND v(dout1_57) AT=235.025n

* CHECK dout1_58 Vdout1_58ck46 = 0.9 time = 235
.meas tran vdout1_58ck46 FIND v(dout1_58) AT=235.025n

* CHECK dout1_59 Vdout1_59ck46 = 0.9 time = 235
.meas tran vdout1_59ck46 FIND v(dout1_59) AT=235.025n

* CHECK dout1_60 Vdout1_60ck46 = 0 time = 235
.meas tran vdout1_60ck46 FIND v(dout1_60) AT=235.025n

* CHECK dout1_61 Vdout1_61ck46 = 0 time = 235
.meas tran vdout1_61ck46 FIND v(dout1_61) AT=235.025n

* CHECK dout1_62 Vdout1_62ck46 = 0.9 time = 235
.meas tran vdout1_62ck46 FIND v(dout1_62) AT=235.025n

* CHECK dout1_63 Vdout1_63ck46 = 0 time = 235
.meas tran vdout1_63ck46 FIND v(dout1_63) AT=235.025n

* CHECK dout1_64 Vdout1_64ck46 = 0 time = 235
.meas tran vdout1_64ck46 FIND v(dout1_64) AT=235.025n

* CHECK dout1_65 Vdout1_65ck46 = 0.9 time = 235
.meas tran vdout1_65ck46 FIND v(dout1_65) AT=235.025n

* CHECK dout1_66 Vdout1_66ck46 = 0 time = 235
.meas tran vdout1_66ck46 FIND v(dout1_66) AT=235.025n

* CHECK dout1_67 Vdout1_67ck46 = 0.9 time = 235
.meas tran vdout1_67ck46 FIND v(dout1_67) AT=235.025n

* CHECK dout1_68 Vdout1_68ck46 = 0 time = 235
.meas tran vdout1_68ck46 FIND v(dout1_68) AT=235.025n

* CHECK dout1_69 Vdout1_69ck46 = 0 time = 235
.meas tran vdout1_69ck46 FIND v(dout1_69) AT=235.025n

* CHECK dout1_70 Vdout1_70ck46 = 0.9 time = 235
.meas tran vdout1_70ck46 FIND v(dout1_70) AT=235.025n

* CHECK dout1_71 Vdout1_71ck46 = 0.9 time = 235
.meas tran vdout1_71ck46 FIND v(dout1_71) AT=235.025n

* CHECK dout1_72 Vdout1_72ck46 = 0 time = 235
.meas tran vdout1_72ck46 FIND v(dout1_72) AT=235.025n

* CHECK dout1_73 Vdout1_73ck46 = 0.9 time = 235
.meas tran vdout1_73ck46 FIND v(dout1_73) AT=235.025n

* CHECK dout1_74 Vdout1_74ck46 = 0 time = 235
.meas tran vdout1_74ck46 FIND v(dout1_74) AT=235.025n

* CHECK dout1_75 Vdout1_75ck46 = 0 time = 235
.meas tran vdout1_75ck46 FIND v(dout1_75) AT=235.025n

* CHECK dout1_76 Vdout1_76ck46 = 0.9 time = 235
.meas tran vdout1_76ck46 FIND v(dout1_76) AT=235.025n

* CHECK dout1_77 Vdout1_77ck46 = 0.9 time = 235
.meas tran vdout1_77ck46 FIND v(dout1_77) AT=235.025n

* CHECK dout1_78 Vdout1_78ck46 = 0 time = 235
.meas tran vdout1_78ck46 FIND v(dout1_78) AT=235.025n

* CHECK dout1_79 Vdout1_79ck46 = 0.9 time = 235
.meas tran vdout1_79ck46 FIND v(dout1_79) AT=235.025n

* CHECK dout1_80 Vdout1_80ck46 = 0 time = 235
.meas tran vdout1_80ck46 FIND v(dout1_80) AT=235.025n

* CHECK dout1_81 Vdout1_81ck46 = 0.9 time = 235
.meas tran vdout1_81ck46 FIND v(dout1_81) AT=235.025n

* CHECK dout1_82 Vdout1_82ck46 = 0.9 time = 235
.meas tran vdout1_82ck46 FIND v(dout1_82) AT=235.025n

* CHECK dout1_83 Vdout1_83ck46 = 0 time = 235
.meas tran vdout1_83ck46 FIND v(dout1_83) AT=235.025n

* CHECK dout1_84 Vdout1_84ck46 = 0.9 time = 235
.meas tran vdout1_84ck46 FIND v(dout1_84) AT=235.025n

* CHECK dout1_85 Vdout1_85ck46 = 0 time = 235
.meas tran vdout1_85ck46 FIND v(dout1_85) AT=235.025n

* CHECK dout1_86 Vdout1_86ck46 = 0 time = 235
.meas tran vdout1_86ck46 FIND v(dout1_86) AT=235.025n

* CHECK dout1_87 Vdout1_87ck46 = 0 time = 235
.meas tran vdout1_87ck46 FIND v(dout1_87) AT=235.025n

* CHECK dout1_88 Vdout1_88ck46 = 0 time = 235
.meas tran vdout1_88ck46 FIND v(dout1_88) AT=235.025n

* CHECK dout1_89 Vdout1_89ck46 = 0.9 time = 235
.meas tran vdout1_89ck46 FIND v(dout1_89) AT=235.025n

* CHECK dout1_90 Vdout1_90ck46 = 0.9 time = 235
.meas tran vdout1_90ck46 FIND v(dout1_90) AT=235.025n

* CHECK dout1_91 Vdout1_91ck46 = 0.9 time = 235
.meas tran vdout1_91ck46 FIND v(dout1_91) AT=235.025n

* CHECK dout1_92 Vdout1_92ck46 = 0 time = 235
.meas tran vdout1_92ck46 FIND v(dout1_92) AT=235.025n

* CHECK dout1_93 Vdout1_93ck46 = 0.9 time = 235
.meas tran vdout1_93ck46 FIND v(dout1_93) AT=235.025n

* CHECK dout1_94 Vdout1_94ck46 = 0 time = 235
.meas tran vdout1_94ck46 FIND v(dout1_94) AT=235.025n

* CHECK dout1_95 Vdout1_95ck46 = 0.9 time = 235
.meas tran vdout1_95ck46 FIND v(dout1_95) AT=235.025n

* CHECK dout1_96 Vdout1_96ck46 = 0 time = 235
.meas tran vdout1_96ck46 FIND v(dout1_96) AT=235.025n

* CHECK dout1_97 Vdout1_97ck46 = 0.9 time = 235
.meas tran vdout1_97ck46 FIND v(dout1_97) AT=235.025n

* CHECK dout1_98 Vdout1_98ck46 = 0.9 time = 235
.meas tran vdout1_98ck46 FIND v(dout1_98) AT=235.025n

* CHECK dout1_99 Vdout1_99ck46 = 0.9 time = 235
.meas tran vdout1_99ck46 FIND v(dout1_99) AT=235.025n

* CHECK dout1_100 Vdout1_100ck46 = 0.9 time = 235
.meas tran vdout1_100ck46 FIND v(dout1_100) AT=235.025n

* CHECK dout1_101 Vdout1_101ck46 = 0 time = 235
.meas tran vdout1_101ck46 FIND v(dout1_101) AT=235.025n

* CHECK dout1_102 Vdout1_102ck46 = 0.9 time = 235
.meas tran vdout1_102ck46 FIND v(dout1_102) AT=235.025n

* CHECK dout1_103 Vdout1_103ck46 = 0 time = 235
.meas tran vdout1_103ck46 FIND v(dout1_103) AT=235.025n

* CHECK dout1_104 Vdout1_104ck46 = 0 time = 235
.meas tran vdout1_104ck46 FIND v(dout1_104) AT=235.025n

* CHECK dout1_105 Vdout1_105ck46 = 0.9 time = 235
.meas tran vdout1_105ck46 FIND v(dout1_105) AT=235.025n

* CHECK dout1_106 Vdout1_106ck46 = 0 time = 235
.meas tran vdout1_106ck46 FIND v(dout1_106) AT=235.025n

* CHECK dout1_107 Vdout1_107ck46 = 0.9 time = 235
.meas tran vdout1_107ck46 FIND v(dout1_107) AT=235.025n

* CHECK dout1_108 Vdout1_108ck46 = 0.9 time = 235
.meas tran vdout1_108ck46 FIND v(dout1_108) AT=235.025n

* CHECK dout1_109 Vdout1_109ck46 = 0.9 time = 235
.meas tran vdout1_109ck46 FIND v(dout1_109) AT=235.025n

* CHECK dout1_110 Vdout1_110ck46 = 0 time = 235
.meas tran vdout1_110ck46 FIND v(dout1_110) AT=235.025n

* CHECK dout1_111 Vdout1_111ck46 = 0 time = 235
.meas tran vdout1_111ck46 FIND v(dout1_111) AT=235.025n

* CHECK dout1_112 Vdout1_112ck46 = 0.9 time = 235
.meas tran vdout1_112ck46 FIND v(dout1_112) AT=235.025n

* CHECK dout1_113 Vdout1_113ck46 = 0 time = 235
.meas tran vdout1_113ck46 FIND v(dout1_113) AT=235.025n

* CHECK dout1_114 Vdout1_114ck46 = 0 time = 235
.meas tran vdout1_114ck46 FIND v(dout1_114) AT=235.025n

* CHECK dout1_115 Vdout1_115ck46 = 0 time = 235
.meas tran vdout1_115ck46 FIND v(dout1_115) AT=235.025n

* CHECK dout1_116 Vdout1_116ck46 = 0.9 time = 235
.meas tran vdout1_116ck46 FIND v(dout1_116) AT=235.025n

* CHECK dout1_117 Vdout1_117ck46 = 0.9 time = 235
.meas tran vdout1_117ck46 FIND v(dout1_117) AT=235.025n

* CHECK dout1_118 Vdout1_118ck46 = 0 time = 235
.meas tran vdout1_118ck46 FIND v(dout1_118) AT=235.025n

* CHECK dout1_119 Vdout1_119ck46 = 0 time = 235
.meas tran vdout1_119ck46 FIND v(dout1_119) AT=235.025n

* CHECK dout1_0 Vdout1_0ck47 = 0.9 time = 240
.meas tran vdout1_0ck47 FIND v(dout1_0) AT=240.025n

* CHECK dout1_1 Vdout1_1ck47 = 0 time = 240
.meas tran vdout1_1ck47 FIND v(dout1_1) AT=240.025n

* CHECK dout1_2 Vdout1_2ck47 = 0 time = 240
.meas tran vdout1_2ck47 FIND v(dout1_2) AT=240.025n

* CHECK dout1_3 Vdout1_3ck47 = 0 time = 240
.meas tran vdout1_3ck47 FIND v(dout1_3) AT=240.025n

* CHECK dout1_4 Vdout1_4ck47 = 0 time = 240
.meas tran vdout1_4ck47 FIND v(dout1_4) AT=240.025n

* CHECK dout1_5 Vdout1_5ck47 = 0.9 time = 240
.meas tran vdout1_5ck47 FIND v(dout1_5) AT=240.025n

* CHECK dout1_6 Vdout1_6ck47 = 0 time = 240
.meas tran vdout1_6ck47 FIND v(dout1_6) AT=240.025n

* CHECK dout1_7 Vdout1_7ck47 = 0.9 time = 240
.meas tran vdout1_7ck47 FIND v(dout1_7) AT=240.025n

* CHECK dout1_8 Vdout1_8ck47 = 0 time = 240
.meas tran vdout1_8ck47 FIND v(dout1_8) AT=240.025n

* CHECK dout1_9 Vdout1_9ck47 = 0 time = 240
.meas tran vdout1_9ck47 FIND v(dout1_9) AT=240.025n

* CHECK dout1_10 Vdout1_10ck47 = 0.9 time = 240
.meas tran vdout1_10ck47 FIND v(dout1_10) AT=240.025n

* CHECK dout1_11 Vdout1_11ck47 = 0.9 time = 240
.meas tran vdout1_11ck47 FIND v(dout1_11) AT=240.025n

* CHECK dout1_12 Vdout1_12ck47 = 0.9 time = 240
.meas tran vdout1_12ck47 FIND v(dout1_12) AT=240.025n

* CHECK dout1_13 Vdout1_13ck47 = 0 time = 240
.meas tran vdout1_13ck47 FIND v(dout1_13) AT=240.025n

* CHECK dout1_14 Vdout1_14ck47 = 0.9 time = 240
.meas tran vdout1_14ck47 FIND v(dout1_14) AT=240.025n

* CHECK dout1_15 Vdout1_15ck47 = 0.9 time = 240
.meas tran vdout1_15ck47 FIND v(dout1_15) AT=240.025n

* CHECK dout1_16 Vdout1_16ck47 = 0 time = 240
.meas tran vdout1_16ck47 FIND v(dout1_16) AT=240.025n

* CHECK dout1_17 Vdout1_17ck47 = 0.9 time = 240
.meas tran vdout1_17ck47 FIND v(dout1_17) AT=240.025n

* CHECK dout1_18 Vdout1_18ck47 = 0.9 time = 240
.meas tran vdout1_18ck47 FIND v(dout1_18) AT=240.025n

* CHECK dout1_19 Vdout1_19ck47 = 0 time = 240
.meas tran vdout1_19ck47 FIND v(dout1_19) AT=240.025n

* CHECK dout1_20 Vdout1_20ck47 = 0.9 time = 240
.meas tran vdout1_20ck47 FIND v(dout1_20) AT=240.025n

* CHECK dout1_21 Vdout1_21ck47 = 0.9 time = 240
.meas tran vdout1_21ck47 FIND v(dout1_21) AT=240.025n

* CHECK dout1_22 Vdout1_22ck47 = 0.9 time = 240
.meas tran vdout1_22ck47 FIND v(dout1_22) AT=240.025n

* CHECK dout1_23 Vdout1_23ck47 = 0 time = 240
.meas tran vdout1_23ck47 FIND v(dout1_23) AT=240.025n

* CHECK dout1_24 Vdout1_24ck47 = 0 time = 240
.meas tran vdout1_24ck47 FIND v(dout1_24) AT=240.025n

* CHECK dout1_25 Vdout1_25ck47 = 0.9 time = 240
.meas tran vdout1_25ck47 FIND v(dout1_25) AT=240.025n

* CHECK dout1_26 Vdout1_26ck47 = 0 time = 240
.meas tran vdout1_26ck47 FIND v(dout1_26) AT=240.025n

* CHECK dout1_27 Vdout1_27ck47 = 0 time = 240
.meas tran vdout1_27ck47 FIND v(dout1_27) AT=240.025n

* CHECK dout1_28 Vdout1_28ck47 = 0.9 time = 240
.meas tran vdout1_28ck47 FIND v(dout1_28) AT=240.025n

* CHECK dout1_29 Vdout1_29ck47 = 0.9 time = 240
.meas tran vdout1_29ck47 FIND v(dout1_29) AT=240.025n

* CHECK dout1_30 Vdout1_30ck47 = 0 time = 240
.meas tran vdout1_30ck47 FIND v(dout1_30) AT=240.025n

* CHECK dout1_31 Vdout1_31ck47 = 0.9 time = 240
.meas tran vdout1_31ck47 FIND v(dout1_31) AT=240.025n

* CHECK dout1_32 Vdout1_32ck47 = 0.9 time = 240
.meas tran vdout1_32ck47 FIND v(dout1_32) AT=240.025n

* CHECK dout1_33 Vdout1_33ck47 = 0.9 time = 240
.meas tran vdout1_33ck47 FIND v(dout1_33) AT=240.025n

* CHECK dout1_34 Vdout1_34ck47 = 0 time = 240
.meas tran vdout1_34ck47 FIND v(dout1_34) AT=240.025n

* CHECK dout1_35 Vdout1_35ck47 = 0 time = 240
.meas tran vdout1_35ck47 FIND v(dout1_35) AT=240.025n

* CHECK dout1_36 Vdout1_36ck47 = 0 time = 240
.meas tran vdout1_36ck47 FIND v(dout1_36) AT=240.025n

* CHECK dout1_37 Vdout1_37ck47 = 0 time = 240
.meas tran vdout1_37ck47 FIND v(dout1_37) AT=240.025n

* CHECK dout1_38 Vdout1_38ck47 = 0 time = 240
.meas tran vdout1_38ck47 FIND v(dout1_38) AT=240.025n

* CHECK dout1_39 Vdout1_39ck47 = 0.9 time = 240
.meas tran vdout1_39ck47 FIND v(dout1_39) AT=240.025n

* CHECK dout1_40 Vdout1_40ck47 = 0 time = 240
.meas tran vdout1_40ck47 FIND v(dout1_40) AT=240.025n

* CHECK dout1_41 Vdout1_41ck47 = 0.9 time = 240
.meas tran vdout1_41ck47 FIND v(dout1_41) AT=240.025n

* CHECK dout1_42 Vdout1_42ck47 = 0 time = 240
.meas tran vdout1_42ck47 FIND v(dout1_42) AT=240.025n

* CHECK dout1_43 Vdout1_43ck47 = 0.9 time = 240
.meas tran vdout1_43ck47 FIND v(dout1_43) AT=240.025n

* CHECK dout1_44 Vdout1_44ck47 = 0 time = 240
.meas tran vdout1_44ck47 FIND v(dout1_44) AT=240.025n

* CHECK dout1_45 Vdout1_45ck47 = 0.9 time = 240
.meas tran vdout1_45ck47 FIND v(dout1_45) AT=240.025n

* CHECK dout1_46 Vdout1_46ck47 = 0 time = 240
.meas tran vdout1_46ck47 FIND v(dout1_46) AT=240.025n

* CHECK dout1_47 Vdout1_47ck47 = 0.9 time = 240
.meas tran vdout1_47ck47 FIND v(dout1_47) AT=240.025n

* CHECK dout1_48 Vdout1_48ck47 = 0.9 time = 240
.meas tran vdout1_48ck47 FIND v(dout1_48) AT=240.025n

* CHECK dout1_49 Vdout1_49ck47 = 0.9 time = 240
.meas tran vdout1_49ck47 FIND v(dout1_49) AT=240.025n

* CHECK dout1_50 Vdout1_50ck47 = 0 time = 240
.meas tran vdout1_50ck47 FIND v(dout1_50) AT=240.025n

* CHECK dout1_51 Vdout1_51ck47 = 0 time = 240
.meas tran vdout1_51ck47 FIND v(dout1_51) AT=240.025n

* CHECK dout1_52 Vdout1_52ck47 = 0 time = 240
.meas tran vdout1_52ck47 FIND v(dout1_52) AT=240.025n

* CHECK dout1_53 Vdout1_53ck47 = 0.9 time = 240
.meas tran vdout1_53ck47 FIND v(dout1_53) AT=240.025n

* CHECK dout1_54 Vdout1_54ck47 = 0.9 time = 240
.meas tran vdout1_54ck47 FIND v(dout1_54) AT=240.025n

* CHECK dout1_55 Vdout1_55ck47 = 0 time = 240
.meas tran vdout1_55ck47 FIND v(dout1_55) AT=240.025n

* CHECK dout1_56 Vdout1_56ck47 = 0.9 time = 240
.meas tran vdout1_56ck47 FIND v(dout1_56) AT=240.025n

* CHECK dout1_57 Vdout1_57ck47 = 0 time = 240
.meas tran vdout1_57ck47 FIND v(dout1_57) AT=240.025n

* CHECK dout1_58 Vdout1_58ck47 = 0.9 time = 240
.meas tran vdout1_58ck47 FIND v(dout1_58) AT=240.025n

* CHECK dout1_59 Vdout1_59ck47 = 0.9 time = 240
.meas tran vdout1_59ck47 FIND v(dout1_59) AT=240.025n

* CHECK dout1_60 Vdout1_60ck47 = 0.9 time = 240
.meas tran vdout1_60ck47 FIND v(dout1_60) AT=240.025n

* CHECK dout1_61 Vdout1_61ck47 = 0.9 time = 240
.meas tran vdout1_61ck47 FIND v(dout1_61) AT=240.025n

* CHECK dout1_62 Vdout1_62ck47 = 0 time = 240
.meas tran vdout1_62ck47 FIND v(dout1_62) AT=240.025n

* CHECK dout1_63 Vdout1_63ck47 = 0.9 time = 240
.meas tran vdout1_63ck47 FIND v(dout1_63) AT=240.025n

* CHECK dout1_64 Vdout1_64ck47 = 0 time = 240
.meas tran vdout1_64ck47 FIND v(dout1_64) AT=240.025n

* CHECK dout1_65 Vdout1_65ck47 = 0.9 time = 240
.meas tran vdout1_65ck47 FIND v(dout1_65) AT=240.025n

* CHECK dout1_66 Vdout1_66ck47 = 0 time = 240
.meas tran vdout1_66ck47 FIND v(dout1_66) AT=240.025n

* CHECK dout1_67 Vdout1_67ck47 = 0.9 time = 240
.meas tran vdout1_67ck47 FIND v(dout1_67) AT=240.025n

* CHECK dout1_68 Vdout1_68ck47 = 0.9 time = 240
.meas tran vdout1_68ck47 FIND v(dout1_68) AT=240.025n

* CHECK dout1_69 Vdout1_69ck47 = 0 time = 240
.meas tran vdout1_69ck47 FIND v(dout1_69) AT=240.025n

* CHECK dout1_70 Vdout1_70ck47 = 0 time = 240
.meas tran vdout1_70ck47 FIND v(dout1_70) AT=240.025n

* CHECK dout1_71 Vdout1_71ck47 = 0 time = 240
.meas tran vdout1_71ck47 FIND v(dout1_71) AT=240.025n

* CHECK dout1_72 Vdout1_72ck47 = 0.9 time = 240
.meas tran vdout1_72ck47 FIND v(dout1_72) AT=240.025n

* CHECK dout1_73 Vdout1_73ck47 = 0 time = 240
.meas tran vdout1_73ck47 FIND v(dout1_73) AT=240.025n

* CHECK dout1_74 Vdout1_74ck47 = 0 time = 240
.meas tran vdout1_74ck47 FIND v(dout1_74) AT=240.025n

* CHECK dout1_75 Vdout1_75ck47 = 0.9 time = 240
.meas tran vdout1_75ck47 FIND v(dout1_75) AT=240.025n

* CHECK dout1_76 Vdout1_76ck47 = 0.9 time = 240
.meas tran vdout1_76ck47 FIND v(dout1_76) AT=240.025n

* CHECK dout1_77 Vdout1_77ck47 = 0 time = 240
.meas tran vdout1_77ck47 FIND v(dout1_77) AT=240.025n

* CHECK dout1_78 Vdout1_78ck47 = 0.9 time = 240
.meas tran vdout1_78ck47 FIND v(dout1_78) AT=240.025n

* CHECK dout1_79 Vdout1_79ck47 = 0.9 time = 240
.meas tran vdout1_79ck47 FIND v(dout1_79) AT=240.025n

* CHECK dout1_80 Vdout1_80ck47 = 0 time = 240
.meas tran vdout1_80ck47 FIND v(dout1_80) AT=240.025n

* CHECK dout1_81 Vdout1_81ck47 = 0.9 time = 240
.meas tran vdout1_81ck47 FIND v(dout1_81) AT=240.025n

* CHECK dout1_82 Vdout1_82ck47 = 0 time = 240
.meas tran vdout1_82ck47 FIND v(dout1_82) AT=240.025n

* CHECK dout1_83 Vdout1_83ck47 = 0 time = 240
.meas tran vdout1_83ck47 FIND v(dout1_83) AT=240.025n

* CHECK dout1_84 Vdout1_84ck47 = 0 time = 240
.meas tran vdout1_84ck47 FIND v(dout1_84) AT=240.025n

* CHECK dout1_85 Vdout1_85ck47 = 0.9 time = 240
.meas tran vdout1_85ck47 FIND v(dout1_85) AT=240.025n

* CHECK dout1_86 Vdout1_86ck47 = 0 time = 240
.meas tran vdout1_86ck47 FIND v(dout1_86) AT=240.025n

* CHECK dout1_87 Vdout1_87ck47 = 0 time = 240
.meas tran vdout1_87ck47 FIND v(dout1_87) AT=240.025n

* CHECK dout1_88 Vdout1_88ck47 = 0 time = 240
.meas tran vdout1_88ck47 FIND v(dout1_88) AT=240.025n

* CHECK dout1_89 Vdout1_89ck47 = 0.9 time = 240
.meas tran vdout1_89ck47 FIND v(dout1_89) AT=240.025n

* CHECK dout1_90 Vdout1_90ck47 = 0 time = 240
.meas tran vdout1_90ck47 FIND v(dout1_90) AT=240.025n

* CHECK dout1_91 Vdout1_91ck47 = 0 time = 240
.meas tran vdout1_91ck47 FIND v(dout1_91) AT=240.025n

* CHECK dout1_92 Vdout1_92ck47 = 0 time = 240
.meas tran vdout1_92ck47 FIND v(dout1_92) AT=240.025n

* CHECK dout1_93 Vdout1_93ck47 = 0.9 time = 240
.meas tran vdout1_93ck47 FIND v(dout1_93) AT=240.025n

* CHECK dout1_94 Vdout1_94ck47 = 0.9 time = 240
.meas tran vdout1_94ck47 FIND v(dout1_94) AT=240.025n

* CHECK dout1_95 Vdout1_95ck47 = 0.9 time = 240
.meas tran vdout1_95ck47 FIND v(dout1_95) AT=240.025n

* CHECK dout1_96 Vdout1_96ck47 = 0.9 time = 240
.meas tran vdout1_96ck47 FIND v(dout1_96) AT=240.025n

* CHECK dout1_97 Vdout1_97ck47 = 0.9 time = 240
.meas tran vdout1_97ck47 FIND v(dout1_97) AT=240.025n

* CHECK dout1_98 Vdout1_98ck47 = 0 time = 240
.meas tran vdout1_98ck47 FIND v(dout1_98) AT=240.025n

* CHECK dout1_99 Vdout1_99ck47 = 0 time = 240
.meas tran vdout1_99ck47 FIND v(dout1_99) AT=240.025n

* CHECK dout1_100 Vdout1_100ck47 = 0.9 time = 240
.meas tran vdout1_100ck47 FIND v(dout1_100) AT=240.025n

* CHECK dout1_101 Vdout1_101ck47 = 0 time = 240
.meas tran vdout1_101ck47 FIND v(dout1_101) AT=240.025n

* CHECK dout1_102 Vdout1_102ck47 = 0.9 time = 240
.meas tran vdout1_102ck47 FIND v(dout1_102) AT=240.025n

* CHECK dout1_103 Vdout1_103ck47 = 0.9 time = 240
.meas tran vdout1_103ck47 FIND v(dout1_103) AT=240.025n

* CHECK dout1_104 Vdout1_104ck47 = 0.9 time = 240
.meas tran vdout1_104ck47 FIND v(dout1_104) AT=240.025n

* CHECK dout1_105 Vdout1_105ck47 = 0 time = 240
.meas tran vdout1_105ck47 FIND v(dout1_105) AT=240.025n

* CHECK dout1_106 Vdout1_106ck47 = 0 time = 240
.meas tran vdout1_106ck47 FIND v(dout1_106) AT=240.025n

* CHECK dout1_107 Vdout1_107ck47 = 0 time = 240
.meas tran vdout1_107ck47 FIND v(dout1_107) AT=240.025n

* CHECK dout1_108 Vdout1_108ck47 = 0.9 time = 240
.meas tran vdout1_108ck47 FIND v(dout1_108) AT=240.025n

* CHECK dout1_109 Vdout1_109ck47 = 0 time = 240
.meas tran vdout1_109ck47 FIND v(dout1_109) AT=240.025n

* CHECK dout1_110 Vdout1_110ck47 = 0 time = 240
.meas tran vdout1_110ck47 FIND v(dout1_110) AT=240.025n

* CHECK dout1_111 Vdout1_111ck47 = 0.9 time = 240
.meas tran vdout1_111ck47 FIND v(dout1_111) AT=240.025n

* CHECK dout1_112 Vdout1_112ck47 = 0 time = 240
.meas tran vdout1_112ck47 FIND v(dout1_112) AT=240.025n

* CHECK dout1_113 Vdout1_113ck47 = 0.9 time = 240
.meas tran vdout1_113ck47 FIND v(dout1_113) AT=240.025n

* CHECK dout1_114 Vdout1_114ck47 = 0 time = 240
.meas tran vdout1_114ck47 FIND v(dout1_114) AT=240.025n

* CHECK dout1_115 Vdout1_115ck47 = 0 time = 240
.meas tran vdout1_115ck47 FIND v(dout1_115) AT=240.025n

* CHECK dout1_116 Vdout1_116ck47 = 0 time = 240
.meas tran vdout1_116ck47 FIND v(dout1_116) AT=240.025n

* CHECK dout1_117 Vdout1_117ck47 = 0.9 time = 240
.meas tran vdout1_117ck47 FIND v(dout1_117) AT=240.025n

* CHECK dout1_118 Vdout1_118ck47 = 0 time = 240
.meas tran vdout1_118ck47 FIND v(dout1_118) AT=240.025n

* CHECK dout1_119 Vdout1_119ck47 = 0.9 time = 240
.meas tran vdout1_119ck47 FIND v(dout1_119) AT=240.025n

* CHECK dout1_0 Vdout1_0ck49 = 0 time = 250
.meas tran vdout1_0ck49 FIND v(dout1_0) AT=250.025n

* CHECK dout1_1 Vdout1_1ck49 = 0 time = 250
.meas tran vdout1_1ck49 FIND v(dout1_1) AT=250.025n

* CHECK dout1_2 Vdout1_2ck49 = 0 time = 250
.meas tran vdout1_2ck49 FIND v(dout1_2) AT=250.025n

* CHECK dout1_3 Vdout1_3ck49 = 0 time = 250
.meas tran vdout1_3ck49 FIND v(dout1_3) AT=250.025n

* CHECK dout1_4 Vdout1_4ck49 = 0.9 time = 250
.meas tran vdout1_4ck49 FIND v(dout1_4) AT=250.025n

* CHECK dout1_5 Vdout1_5ck49 = 0.9 time = 250
.meas tran vdout1_5ck49 FIND v(dout1_5) AT=250.025n

* CHECK dout1_6 Vdout1_6ck49 = 0.9 time = 250
.meas tran vdout1_6ck49 FIND v(dout1_6) AT=250.025n

* CHECK dout1_7 Vdout1_7ck49 = 0.9 time = 250
.meas tran vdout1_7ck49 FIND v(dout1_7) AT=250.025n

* CHECK dout1_8 Vdout1_8ck49 = 0.9 time = 250
.meas tran vdout1_8ck49 FIND v(dout1_8) AT=250.025n

* CHECK dout1_9 Vdout1_9ck49 = 0.9 time = 250
.meas tran vdout1_9ck49 FIND v(dout1_9) AT=250.025n

* CHECK dout1_10 Vdout1_10ck49 = 0 time = 250
.meas tran vdout1_10ck49 FIND v(dout1_10) AT=250.025n

* CHECK dout1_11 Vdout1_11ck49 = 0.9 time = 250
.meas tran vdout1_11ck49 FIND v(dout1_11) AT=250.025n

* CHECK dout1_12 Vdout1_12ck49 = 0 time = 250
.meas tran vdout1_12ck49 FIND v(dout1_12) AT=250.025n

* CHECK dout1_13 Vdout1_13ck49 = 0.9 time = 250
.meas tran vdout1_13ck49 FIND v(dout1_13) AT=250.025n

* CHECK dout1_14 Vdout1_14ck49 = 0 time = 250
.meas tran vdout1_14ck49 FIND v(dout1_14) AT=250.025n

* CHECK dout1_15 Vdout1_15ck49 = 0 time = 250
.meas tran vdout1_15ck49 FIND v(dout1_15) AT=250.025n

* CHECK dout1_16 Vdout1_16ck49 = 0.9 time = 250
.meas tran vdout1_16ck49 FIND v(dout1_16) AT=250.025n

* CHECK dout1_17 Vdout1_17ck49 = 0 time = 250
.meas tran vdout1_17ck49 FIND v(dout1_17) AT=250.025n

* CHECK dout1_18 Vdout1_18ck49 = 0 time = 250
.meas tran vdout1_18ck49 FIND v(dout1_18) AT=250.025n

* CHECK dout1_19 Vdout1_19ck49 = 0.9 time = 250
.meas tran vdout1_19ck49 FIND v(dout1_19) AT=250.025n

* CHECK dout1_20 Vdout1_20ck49 = 0.9 time = 250
.meas tran vdout1_20ck49 FIND v(dout1_20) AT=250.025n

* CHECK dout1_21 Vdout1_21ck49 = 0 time = 250
.meas tran vdout1_21ck49 FIND v(dout1_21) AT=250.025n

* CHECK dout1_22 Vdout1_22ck49 = 0.9 time = 250
.meas tran vdout1_22ck49 FIND v(dout1_22) AT=250.025n

* CHECK dout1_23 Vdout1_23ck49 = 0.9 time = 250
.meas tran vdout1_23ck49 FIND v(dout1_23) AT=250.025n

* CHECK dout1_24 Vdout1_24ck49 = 0 time = 250
.meas tran vdout1_24ck49 FIND v(dout1_24) AT=250.025n

* CHECK dout1_25 Vdout1_25ck49 = 0 time = 250
.meas tran vdout1_25ck49 FIND v(dout1_25) AT=250.025n

* CHECK dout1_26 Vdout1_26ck49 = 0.9 time = 250
.meas tran vdout1_26ck49 FIND v(dout1_26) AT=250.025n

* CHECK dout1_27 Vdout1_27ck49 = 0.9 time = 250
.meas tran vdout1_27ck49 FIND v(dout1_27) AT=250.025n

* CHECK dout1_28 Vdout1_28ck49 = 0 time = 250
.meas tran vdout1_28ck49 FIND v(dout1_28) AT=250.025n

* CHECK dout1_29 Vdout1_29ck49 = 0 time = 250
.meas tran vdout1_29ck49 FIND v(dout1_29) AT=250.025n

* CHECK dout1_30 Vdout1_30ck49 = 0.9 time = 250
.meas tran vdout1_30ck49 FIND v(dout1_30) AT=250.025n

* CHECK dout1_31 Vdout1_31ck49 = 0.9 time = 250
.meas tran vdout1_31ck49 FIND v(dout1_31) AT=250.025n

* CHECK dout1_32 Vdout1_32ck49 = 0 time = 250
.meas tran vdout1_32ck49 FIND v(dout1_32) AT=250.025n

* CHECK dout1_33 Vdout1_33ck49 = 0 time = 250
.meas tran vdout1_33ck49 FIND v(dout1_33) AT=250.025n

* CHECK dout1_34 Vdout1_34ck49 = 0 time = 250
.meas tran vdout1_34ck49 FIND v(dout1_34) AT=250.025n

* CHECK dout1_35 Vdout1_35ck49 = 0 time = 250
.meas tran vdout1_35ck49 FIND v(dout1_35) AT=250.025n

* CHECK dout1_36 Vdout1_36ck49 = 0 time = 250
.meas tran vdout1_36ck49 FIND v(dout1_36) AT=250.025n

* CHECK dout1_37 Vdout1_37ck49 = 0 time = 250
.meas tran vdout1_37ck49 FIND v(dout1_37) AT=250.025n

* CHECK dout1_38 Vdout1_38ck49 = 0.9 time = 250
.meas tran vdout1_38ck49 FIND v(dout1_38) AT=250.025n

* CHECK dout1_39 Vdout1_39ck49 = 0 time = 250
.meas tran vdout1_39ck49 FIND v(dout1_39) AT=250.025n

* CHECK dout1_40 Vdout1_40ck49 = 0.9 time = 250
.meas tran vdout1_40ck49 FIND v(dout1_40) AT=250.025n

* CHECK dout1_41 Vdout1_41ck49 = 0 time = 250
.meas tran vdout1_41ck49 FIND v(dout1_41) AT=250.025n

* CHECK dout1_42 Vdout1_42ck49 = 0.9 time = 250
.meas tran vdout1_42ck49 FIND v(dout1_42) AT=250.025n

* CHECK dout1_43 Vdout1_43ck49 = 0.9 time = 250
.meas tran vdout1_43ck49 FIND v(dout1_43) AT=250.025n

* CHECK dout1_44 Vdout1_44ck49 = 0.9 time = 250
.meas tran vdout1_44ck49 FIND v(dout1_44) AT=250.025n

* CHECK dout1_45 Vdout1_45ck49 = 0 time = 250
.meas tran vdout1_45ck49 FIND v(dout1_45) AT=250.025n

* CHECK dout1_46 Vdout1_46ck49 = 0 time = 250
.meas tran vdout1_46ck49 FIND v(dout1_46) AT=250.025n

* CHECK dout1_47 Vdout1_47ck49 = 0 time = 250
.meas tran vdout1_47ck49 FIND v(dout1_47) AT=250.025n

* CHECK dout1_48 Vdout1_48ck49 = 0 time = 250
.meas tran vdout1_48ck49 FIND v(dout1_48) AT=250.025n

* CHECK dout1_49 Vdout1_49ck49 = 0.9 time = 250
.meas tran vdout1_49ck49 FIND v(dout1_49) AT=250.025n

* CHECK dout1_50 Vdout1_50ck49 = 0.9 time = 250
.meas tran vdout1_50ck49 FIND v(dout1_50) AT=250.025n

* CHECK dout1_51 Vdout1_51ck49 = 0 time = 250
.meas tran vdout1_51ck49 FIND v(dout1_51) AT=250.025n

* CHECK dout1_52 Vdout1_52ck49 = 0.9 time = 250
.meas tran vdout1_52ck49 FIND v(dout1_52) AT=250.025n

* CHECK dout1_53 Vdout1_53ck49 = 0.9 time = 250
.meas tran vdout1_53ck49 FIND v(dout1_53) AT=250.025n

* CHECK dout1_54 Vdout1_54ck49 = 0.9 time = 250
.meas tran vdout1_54ck49 FIND v(dout1_54) AT=250.025n

* CHECK dout1_55 Vdout1_55ck49 = 0.9 time = 250
.meas tran vdout1_55ck49 FIND v(dout1_55) AT=250.025n

* CHECK dout1_56 Vdout1_56ck49 = 0.9 time = 250
.meas tran vdout1_56ck49 FIND v(dout1_56) AT=250.025n

* CHECK dout1_57 Vdout1_57ck49 = 0.9 time = 250
.meas tran vdout1_57ck49 FIND v(dout1_57) AT=250.025n

* CHECK dout1_58 Vdout1_58ck49 = 0 time = 250
.meas tran vdout1_58ck49 FIND v(dout1_58) AT=250.025n

* CHECK dout1_59 Vdout1_59ck49 = 0.9 time = 250
.meas tran vdout1_59ck49 FIND v(dout1_59) AT=250.025n

* CHECK dout1_60 Vdout1_60ck49 = 0.9 time = 250
.meas tran vdout1_60ck49 FIND v(dout1_60) AT=250.025n

* CHECK dout1_61 Vdout1_61ck49 = 0 time = 250
.meas tran vdout1_61ck49 FIND v(dout1_61) AT=250.025n

* CHECK dout1_62 Vdout1_62ck49 = 0 time = 250
.meas tran vdout1_62ck49 FIND v(dout1_62) AT=250.025n

* CHECK dout1_63 Vdout1_63ck49 = 0.9 time = 250
.meas tran vdout1_63ck49 FIND v(dout1_63) AT=250.025n

* CHECK dout1_64 Vdout1_64ck49 = 0 time = 250
.meas tran vdout1_64ck49 FIND v(dout1_64) AT=250.025n

* CHECK dout1_65 Vdout1_65ck49 = 0 time = 250
.meas tran vdout1_65ck49 FIND v(dout1_65) AT=250.025n

* CHECK dout1_66 Vdout1_66ck49 = 0 time = 250
.meas tran vdout1_66ck49 FIND v(dout1_66) AT=250.025n

* CHECK dout1_67 Vdout1_67ck49 = 0 time = 250
.meas tran vdout1_67ck49 FIND v(dout1_67) AT=250.025n

* CHECK dout1_68 Vdout1_68ck49 = 0.9 time = 250
.meas tran vdout1_68ck49 FIND v(dout1_68) AT=250.025n

* CHECK dout1_69 Vdout1_69ck49 = 0 time = 250
.meas tran vdout1_69ck49 FIND v(dout1_69) AT=250.025n

* CHECK dout1_70 Vdout1_70ck49 = 0 time = 250
.meas tran vdout1_70ck49 FIND v(dout1_70) AT=250.025n

* CHECK dout1_71 Vdout1_71ck49 = 0.9 time = 250
.meas tran vdout1_71ck49 FIND v(dout1_71) AT=250.025n

* CHECK dout1_72 Vdout1_72ck49 = 0 time = 250
.meas tran vdout1_72ck49 FIND v(dout1_72) AT=250.025n

* CHECK dout1_73 Vdout1_73ck49 = 0 time = 250
.meas tran vdout1_73ck49 FIND v(dout1_73) AT=250.025n

* CHECK dout1_74 Vdout1_74ck49 = 0.9 time = 250
.meas tran vdout1_74ck49 FIND v(dout1_74) AT=250.025n

* CHECK dout1_75 Vdout1_75ck49 = 0.9 time = 250
.meas tran vdout1_75ck49 FIND v(dout1_75) AT=250.025n

* CHECK dout1_76 Vdout1_76ck49 = 0 time = 250
.meas tran vdout1_76ck49 FIND v(dout1_76) AT=250.025n

* CHECK dout1_77 Vdout1_77ck49 = 0 time = 250
.meas tran vdout1_77ck49 FIND v(dout1_77) AT=250.025n

* CHECK dout1_78 Vdout1_78ck49 = 0.9 time = 250
.meas tran vdout1_78ck49 FIND v(dout1_78) AT=250.025n

* CHECK dout1_79 Vdout1_79ck49 = 0.9 time = 250
.meas tran vdout1_79ck49 FIND v(dout1_79) AT=250.025n

* CHECK dout1_80 Vdout1_80ck49 = 0.9 time = 250
.meas tran vdout1_80ck49 FIND v(dout1_80) AT=250.025n

* CHECK dout1_81 Vdout1_81ck49 = 0.9 time = 250
.meas tran vdout1_81ck49 FIND v(dout1_81) AT=250.025n

* CHECK dout1_82 Vdout1_82ck49 = 0.9 time = 250
.meas tran vdout1_82ck49 FIND v(dout1_82) AT=250.025n

* CHECK dout1_83 Vdout1_83ck49 = 0 time = 250
.meas tran vdout1_83ck49 FIND v(dout1_83) AT=250.025n

* CHECK dout1_84 Vdout1_84ck49 = 0 time = 250
.meas tran vdout1_84ck49 FIND v(dout1_84) AT=250.025n

* CHECK dout1_85 Vdout1_85ck49 = 0 time = 250
.meas tran vdout1_85ck49 FIND v(dout1_85) AT=250.025n

* CHECK dout1_86 Vdout1_86ck49 = 0 time = 250
.meas tran vdout1_86ck49 FIND v(dout1_86) AT=250.025n

* CHECK dout1_87 Vdout1_87ck49 = 0 time = 250
.meas tran vdout1_87ck49 FIND v(dout1_87) AT=250.025n

* CHECK dout1_88 Vdout1_88ck49 = 0 time = 250
.meas tran vdout1_88ck49 FIND v(dout1_88) AT=250.025n

* CHECK dout1_89 Vdout1_89ck49 = 0.9 time = 250
.meas tran vdout1_89ck49 FIND v(dout1_89) AT=250.025n

* CHECK dout1_90 Vdout1_90ck49 = 0.9 time = 250
.meas tran vdout1_90ck49 FIND v(dout1_90) AT=250.025n

* CHECK dout1_91 Vdout1_91ck49 = 0 time = 250
.meas tran vdout1_91ck49 FIND v(dout1_91) AT=250.025n

* CHECK dout1_92 Vdout1_92ck49 = 0 time = 250
.meas tran vdout1_92ck49 FIND v(dout1_92) AT=250.025n

* CHECK dout1_93 Vdout1_93ck49 = 0 time = 250
.meas tran vdout1_93ck49 FIND v(dout1_93) AT=250.025n

* CHECK dout1_94 Vdout1_94ck49 = 0.9 time = 250
.meas tran vdout1_94ck49 FIND v(dout1_94) AT=250.025n

* CHECK dout1_95 Vdout1_95ck49 = 0.9 time = 250
.meas tran vdout1_95ck49 FIND v(dout1_95) AT=250.025n

* CHECK dout1_96 Vdout1_96ck49 = 0 time = 250
.meas tran vdout1_96ck49 FIND v(dout1_96) AT=250.025n

* CHECK dout1_97 Vdout1_97ck49 = 0.9 time = 250
.meas tran vdout1_97ck49 FIND v(dout1_97) AT=250.025n

* CHECK dout1_98 Vdout1_98ck49 = 0 time = 250
.meas tran vdout1_98ck49 FIND v(dout1_98) AT=250.025n

* CHECK dout1_99 Vdout1_99ck49 = 0.9 time = 250
.meas tran vdout1_99ck49 FIND v(dout1_99) AT=250.025n

* CHECK dout1_100 Vdout1_100ck49 = 0.9 time = 250
.meas tran vdout1_100ck49 FIND v(dout1_100) AT=250.025n

* CHECK dout1_101 Vdout1_101ck49 = 0.9 time = 250
.meas tran vdout1_101ck49 FIND v(dout1_101) AT=250.025n

* CHECK dout1_102 Vdout1_102ck49 = 0 time = 250
.meas tran vdout1_102ck49 FIND v(dout1_102) AT=250.025n

* CHECK dout1_103 Vdout1_103ck49 = 0 time = 250
.meas tran vdout1_103ck49 FIND v(dout1_103) AT=250.025n

* CHECK dout1_104 Vdout1_104ck49 = 0 time = 250
.meas tran vdout1_104ck49 FIND v(dout1_104) AT=250.025n

* CHECK dout1_105 Vdout1_105ck49 = 0.9 time = 250
.meas tran vdout1_105ck49 FIND v(dout1_105) AT=250.025n

* CHECK dout1_106 Vdout1_106ck49 = 0.9 time = 250
.meas tran vdout1_106ck49 FIND v(dout1_106) AT=250.025n

* CHECK dout1_107 Vdout1_107ck49 = 0.9 time = 250
.meas tran vdout1_107ck49 FIND v(dout1_107) AT=250.025n

* CHECK dout1_108 Vdout1_108ck49 = 0 time = 250
.meas tran vdout1_108ck49 FIND v(dout1_108) AT=250.025n

* CHECK dout1_109 Vdout1_109ck49 = 0 time = 250
.meas tran vdout1_109ck49 FIND v(dout1_109) AT=250.025n

* CHECK dout1_110 Vdout1_110ck49 = 0 time = 250
.meas tran vdout1_110ck49 FIND v(dout1_110) AT=250.025n

* CHECK dout1_111 Vdout1_111ck49 = 0.9 time = 250
.meas tran vdout1_111ck49 FIND v(dout1_111) AT=250.025n

* CHECK dout1_112 Vdout1_112ck49 = 0 time = 250
.meas tran vdout1_112ck49 FIND v(dout1_112) AT=250.025n

* CHECK dout1_113 Vdout1_113ck49 = 0.9 time = 250
.meas tran vdout1_113ck49 FIND v(dout1_113) AT=250.025n

* CHECK dout1_114 Vdout1_114ck49 = 0 time = 250
.meas tran vdout1_114ck49 FIND v(dout1_114) AT=250.025n

* CHECK dout1_115 Vdout1_115ck49 = 0 time = 250
.meas tran vdout1_115ck49 FIND v(dout1_115) AT=250.025n

* CHECK dout1_116 Vdout1_116ck49 = 0.9 time = 250
.meas tran vdout1_116ck49 FIND v(dout1_116) AT=250.025n

* CHECK dout1_117 Vdout1_117ck49 = 0.9 time = 250
.meas tran vdout1_117ck49 FIND v(dout1_117) AT=250.025n

* CHECK dout1_118 Vdout1_118ck49 = 0.9 time = 250
.meas tran vdout1_118ck49 FIND v(dout1_118) AT=250.025n

* CHECK dout1_119 Vdout1_119ck49 = 0 time = 250
.meas tran vdout1_119ck49 FIND v(dout1_119) AT=250.025n

* CHECK dout1_0 Vdout1_0ck50 = 0 time = 255
.meas tran vdout1_0ck50 FIND v(dout1_0) AT=255.025n

* CHECK dout1_1 Vdout1_1ck50 = 0 time = 255
.meas tran vdout1_1ck50 FIND v(dout1_1) AT=255.025n

* CHECK dout1_2 Vdout1_2ck50 = 0.9 time = 255
.meas tran vdout1_2ck50 FIND v(dout1_2) AT=255.025n

* CHECK dout1_3 Vdout1_3ck50 = 0.9 time = 255
.meas tran vdout1_3ck50 FIND v(dout1_3) AT=255.025n

* CHECK dout1_4 Vdout1_4ck50 = 0 time = 255
.meas tran vdout1_4ck50 FIND v(dout1_4) AT=255.025n

* CHECK dout1_5 Vdout1_5ck50 = 0 time = 255
.meas tran vdout1_5ck50 FIND v(dout1_5) AT=255.025n

* CHECK dout1_6 Vdout1_6ck50 = 0 time = 255
.meas tran vdout1_6ck50 FIND v(dout1_6) AT=255.025n

* CHECK dout1_7 Vdout1_7ck50 = 0 time = 255
.meas tran vdout1_7ck50 FIND v(dout1_7) AT=255.025n

* CHECK dout1_8 Vdout1_8ck50 = 0 time = 255
.meas tran vdout1_8ck50 FIND v(dout1_8) AT=255.025n

* CHECK dout1_9 Vdout1_9ck50 = 0.9 time = 255
.meas tran vdout1_9ck50 FIND v(dout1_9) AT=255.025n

* CHECK dout1_10 Vdout1_10ck50 = 0 time = 255
.meas tran vdout1_10ck50 FIND v(dout1_10) AT=255.025n

* CHECK dout1_11 Vdout1_11ck50 = 0.9 time = 255
.meas tran vdout1_11ck50 FIND v(dout1_11) AT=255.025n

* CHECK dout1_12 Vdout1_12ck50 = 0.9 time = 255
.meas tran vdout1_12ck50 FIND v(dout1_12) AT=255.025n

* CHECK dout1_13 Vdout1_13ck50 = 0.9 time = 255
.meas tran vdout1_13ck50 FIND v(dout1_13) AT=255.025n

* CHECK dout1_14 Vdout1_14ck50 = 0.9 time = 255
.meas tran vdout1_14ck50 FIND v(dout1_14) AT=255.025n

* CHECK dout1_15 Vdout1_15ck50 = 0 time = 255
.meas tran vdout1_15ck50 FIND v(dout1_15) AT=255.025n

* CHECK dout1_16 Vdout1_16ck50 = 0 time = 255
.meas tran vdout1_16ck50 FIND v(dout1_16) AT=255.025n

* CHECK dout1_17 Vdout1_17ck50 = 0 time = 255
.meas tran vdout1_17ck50 FIND v(dout1_17) AT=255.025n

* CHECK dout1_18 Vdout1_18ck50 = 0.9 time = 255
.meas tran vdout1_18ck50 FIND v(dout1_18) AT=255.025n

* CHECK dout1_19 Vdout1_19ck50 = 0 time = 255
.meas tran vdout1_19ck50 FIND v(dout1_19) AT=255.025n

* CHECK dout1_20 Vdout1_20ck50 = 0.9 time = 255
.meas tran vdout1_20ck50 FIND v(dout1_20) AT=255.025n

* CHECK dout1_21 Vdout1_21ck50 = 0 time = 255
.meas tran vdout1_21ck50 FIND v(dout1_21) AT=255.025n

* CHECK dout1_22 Vdout1_22ck50 = 0 time = 255
.meas tran vdout1_22ck50 FIND v(dout1_22) AT=255.025n

* CHECK dout1_23 Vdout1_23ck50 = 0.9 time = 255
.meas tran vdout1_23ck50 FIND v(dout1_23) AT=255.025n

* CHECK dout1_24 Vdout1_24ck50 = 0.9 time = 255
.meas tran vdout1_24ck50 FIND v(dout1_24) AT=255.025n

* CHECK dout1_25 Vdout1_25ck50 = 0.9 time = 255
.meas tran vdout1_25ck50 FIND v(dout1_25) AT=255.025n

* CHECK dout1_26 Vdout1_26ck50 = 0.9 time = 255
.meas tran vdout1_26ck50 FIND v(dout1_26) AT=255.025n

* CHECK dout1_27 Vdout1_27ck50 = 0 time = 255
.meas tran vdout1_27ck50 FIND v(dout1_27) AT=255.025n

* CHECK dout1_28 Vdout1_28ck50 = 0.9 time = 255
.meas tran vdout1_28ck50 FIND v(dout1_28) AT=255.025n

* CHECK dout1_29 Vdout1_29ck50 = 0.9 time = 255
.meas tran vdout1_29ck50 FIND v(dout1_29) AT=255.025n

* CHECK dout1_30 Vdout1_30ck50 = 0.9 time = 255
.meas tran vdout1_30ck50 FIND v(dout1_30) AT=255.025n

* CHECK dout1_31 Vdout1_31ck50 = 0 time = 255
.meas tran vdout1_31ck50 FIND v(dout1_31) AT=255.025n

* CHECK dout1_32 Vdout1_32ck50 = 0.9 time = 255
.meas tran vdout1_32ck50 FIND v(dout1_32) AT=255.025n

* CHECK dout1_33 Vdout1_33ck50 = 0 time = 255
.meas tran vdout1_33ck50 FIND v(dout1_33) AT=255.025n

* CHECK dout1_34 Vdout1_34ck50 = 0.9 time = 255
.meas tran vdout1_34ck50 FIND v(dout1_34) AT=255.025n

* CHECK dout1_35 Vdout1_35ck50 = 0.9 time = 255
.meas tran vdout1_35ck50 FIND v(dout1_35) AT=255.025n

* CHECK dout1_36 Vdout1_36ck50 = 0 time = 255
.meas tran vdout1_36ck50 FIND v(dout1_36) AT=255.025n

* CHECK dout1_37 Vdout1_37ck50 = 0 time = 255
.meas tran vdout1_37ck50 FIND v(dout1_37) AT=255.025n

* CHECK dout1_38 Vdout1_38ck50 = 0.9 time = 255
.meas tran vdout1_38ck50 FIND v(dout1_38) AT=255.025n

* CHECK dout1_39 Vdout1_39ck50 = 0.9 time = 255
.meas tran vdout1_39ck50 FIND v(dout1_39) AT=255.025n

* CHECK dout1_40 Vdout1_40ck50 = 0.9 time = 255
.meas tran vdout1_40ck50 FIND v(dout1_40) AT=255.025n

* CHECK dout1_41 Vdout1_41ck50 = 0 time = 255
.meas tran vdout1_41ck50 FIND v(dout1_41) AT=255.025n

* CHECK dout1_42 Vdout1_42ck50 = 0 time = 255
.meas tran vdout1_42ck50 FIND v(dout1_42) AT=255.025n

* CHECK dout1_43 Vdout1_43ck50 = 0 time = 255
.meas tran vdout1_43ck50 FIND v(dout1_43) AT=255.025n

* CHECK dout1_44 Vdout1_44ck50 = 0.9 time = 255
.meas tran vdout1_44ck50 FIND v(dout1_44) AT=255.025n

* CHECK dout1_45 Vdout1_45ck50 = 0 time = 255
.meas tran vdout1_45ck50 FIND v(dout1_45) AT=255.025n

* CHECK dout1_46 Vdout1_46ck50 = 0 time = 255
.meas tran vdout1_46ck50 FIND v(dout1_46) AT=255.025n

* CHECK dout1_47 Vdout1_47ck50 = 0 time = 255
.meas tran vdout1_47ck50 FIND v(dout1_47) AT=255.025n

* CHECK dout1_48 Vdout1_48ck50 = 0 time = 255
.meas tran vdout1_48ck50 FIND v(dout1_48) AT=255.025n

* CHECK dout1_49 Vdout1_49ck50 = 0.9 time = 255
.meas tran vdout1_49ck50 FIND v(dout1_49) AT=255.025n

* CHECK dout1_50 Vdout1_50ck50 = 0 time = 255
.meas tran vdout1_50ck50 FIND v(dout1_50) AT=255.025n

* CHECK dout1_51 Vdout1_51ck50 = 0.9 time = 255
.meas tran vdout1_51ck50 FIND v(dout1_51) AT=255.025n

* CHECK dout1_52 Vdout1_52ck50 = 0 time = 255
.meas tran vdout1_52ck50 FIND v(dout1_52) AT=255.025n

* CHECK dout1_53 Vdout1_53ck50 = 0 time = 255
.meas tran vdout1_53ck50 FIND v(dout1_53) AT=255.025n

* CHECK dout1_54 Vdout1_54ck50 = 0.9 time = 255
.meas tran vdout1_54ck50 FIND v(dout1_54) AT=255.025n

* CHECK dout1_55 Vdout1_55ck50 = 0.9 time = 255
.meas tran vdout1_55ck50 FIND v(dout1_55) AT=255.025n

* CHECK dout1_56 Vdout1_56ck50 = 0 time = 255
.meas tran vdout1_56ck50 FIND v(dout1_56) AT=255.025n

* CHECK dout1_57 Vdout1_57ck50 = 0.9 time = 255
.meas tran vdout1_57ck50 FIND v(dout1_57) AT=255.025n

* CHECK dout1_58 Vdout1_58ck50 = 0 time = 255
.meas tran vdout1_58ck50 FIND v(dout1_58) AT=255.025n

* CHECK dout1_59 Vdout1_59ck50 = 0 time = 255
.meas tran vdout1_59ck50 FIND v(dout1_59) AT=255.025n

* CHECK dout1_60 Vdout1_60ck50 = 0 time = 255
.meas tran vdout1_60ck50 FIND v(dout1_60) AT=255.025n

* CHECK dout1_61 Vdout1_61ck50 = 0 time = 255
.meas tran vdout1_61ck50 FIND v(dout1_61) AT=255.025n

* CHECK dout1_62 Vdout1_62ck50 = 0.9 time = 255
.meas tran vdout1_62ck50 FIND v(dout1_62) AT=255.025n

* CHECK dout1_63 Vdout1_63ck50 = 0.9 time = 255
.meas tran vdout1_63ck50 FIND v(dout1_63) AT=255.025n

* CHECK dout1_64 Vdout1_64ck50 = 0.9 time = 255
.meas tran vdout1_64ck50 FIND v(dout1_64) AT=255.025n

* CHECK dout1_65 Vdout1_65ck50 = 0 time = 255
.meas tran vdout1_65ck50 FIND v(dout1_65) AT=255.025n

* CHECK dout1_66 Vdout1_66ck50 = 0 time = 255
.meas tran vdout1_66ck50 FIND v(dout1_66) AT=255.025n

* CHECK dout1_67 Vdout1_67ck50 = 0.9 time = 255
.meas tran vdout1_67ck50 FIND v(dout1_67) AT=255.025n

* CHECK dout1_68 Vdout1_68ck50 = 0.9 time = 255
.meas tran vdout1_68ck50 FIND v(dout1_68) AT=255.025n

* CHECK dout1_69 Vdout1_69ck50 = 0 time = 255
.meas tran vdout1_69ck50 FIND v(dout1_69) AT=255.025n

* CHECK dout1_70 Vdout1_70ck50 = 0 time = 255
.meas tran vdout1_70ck50 FIND v(dout1_70) AT=255.025n

* CHECK dout1_71 Vdout1_71ck50 = 0.9 time = 255
.meas tran vdout1_71ck50 FIND v(dout1_71) AT=255.025n

* CHECK dout1_72 Vdout1_72ck50 = 0.9 time = 255
.meas tran vdout1_72ck50 FIND v(dout1_72) AT=255.025n

* CHECK dout1_73 Vdout1_73ck50 = 0.9 time = 255
.meas tran vdout1_73ck50 FIND v(dout1_73) AT=255.025n

* CHECK dout1_74 Vdout1_74ck50 = 0 time = 255
.meas tran vdout1_74ck50 FIND v(dout1_74) AT=255.025n

* CHECK dout1_75 Vdout1_75ck50 = 0.9 time = 255
.meas tran vdout1_75ck50 FIND v(dout1_75) AT=255.025n

* CHECK dout1_76 Vdout1_76ck50 = 0.9 time = 255
.meas tran vdout1_76ck50 FIND v(dout1_76) AT=255.025n

* CHECK dout1_77 Vdout1_77ck50 = 0 time = 255
.meas tran vdout1_77ck50 FIND v(dout1_77) AT=255.025n

* CHECK dout1_78 Vdout1_78ck50 = 0 time = 255
.meas tran vdout1_78ck50 FIND v(dout1_78) AT=255.025n

* CHECK dout1_79 Vdout1_79ck50 = 0.9 time = 255
.meas tran vdout1_79ck50 FIND v(dout1_79) AT=255.025n

* CHECK dout1_80 Vdout1_80ck50 = 0.9 time = 255
.meas tran vdout1_80ck50 FIND v(dout1_80) AT=255.025n

* CHECK dout1_81 Vdout1_81ck50 = 0.9 time = 255
.meas tran vdout1_81ck50 FIND v(dout1_81) AT=255.025n

* CHECK dout1_82 Vdout1_82ck50 = 0.9 time = 255
.meas tran vdout1_82ck50 FIND v(dout1_82) AT=255.025n

* CHECK dout1_83 Vdout1_83ck50 = 0.9 time = 255
.meas tran vdout1_83ck50 FIND v(dout1_83) AT=255.025n

* CHECK dout1_84 Vdout1_84ck50 = 0.9 time = 255
.meas tran vdout1_84ck50 FIND v(dout1_84) AT=255.025n

* CHECK dout1_85 Vdout1_85ck50 = 0.9 time = 255
.meas tran vdout1_85ck50 FIND v(dout1_85) AT=255.025n

* CHECK dout1_86 Vdout1_86ck50 = 0 time = 255
.meas tran vdout1_86ck50 FIND v(dout1_86) AT=255.025n

* CHECK dout1_87 Vdout1_87ck50 = 0.9 time = 255
.meas tran vdout1_87ck50 FIND v(dout1_87) AT=255.025n

* CHECK dout1_88 Vdout1_88ck50 = 0.9 time = 255
.meas tran vdout1_88ck50 FIND v(dout1_88) AT=255.025n

* CHECK dout1_89 Vdout1_89ck50 = 0.9 time = 255
.meas tran vdout1_89ck50 FIND v(dout1_89) AT=255.025n

* CHECK dout1_90 Vdout1_90ck50 = 0 time = 255
.meas tran vdout1_90ck50 FIND v(dout1_90) AT=255.025n

* CHECK dout1_91 Vdout1_91ck50 = 0.9 time = 255
.meas tran vdout1_91ck50 FIND v(dout1_91) AT=255.025n

* CHECK dout1_92 Vdout1_92ck50 = 0.9 time = 255
.meas tran vdout1_92ck50 FIND v(dout1_92) AT=255.025n

* CHECK dout1_93 Vdout1_93ck50 = 0 time = 255
.meas tran vdout1_93ck50 FIND v(dout1_93) AT=255.025n

* CHECK dout1_94 Vdout1_94ck50 = 0 time = 255
.meas tran vdout1_94ck50 FIND v(dout1_94) AT=255.025n

* CHECK dout1_95 Vdout1_95ck50 = 0.9 time = 255
.meas tran vdout1_95ck50 FIND v(dout1_95) AT=255.025n

* CHECK dout1_96 Vdout1_96ck50 = 0.9 time = 255
.meas tran vdout1_96ck50 FIND v(dout1_96) AT=255.025n

* CHECK dout1_97 Vdout1_97ck50 = 0 time = 255
.meas tran vdout1_97ck50 FIND v(dout1_97) AT=255.025n

* CHECK dout1_98 Vdout1_98ck50 = 0.9 time = 255
.meas tran vdout1_98ck50 FIND v(dout1_98) AT=255.025n

* CHECK dout1_99 Vdout1_99ck50 = 0.9 time = 255
.meas tran vdout1_99ck50 FIND v(dout1_99) AT=255.025n

* CHECK dout1_100 Vdout1_100ck50 = 0 time = 255
.meas tran vdout1_100ck50 FIND v(dout1_100) AT=255.025n

* CHECK dout1_101 Vdout1_101ck50 = 0.9 time = 255
.meas tran vdout1_101ck50 FIND v(dout1_101) AT=255.025n

* CHECK dout1_102 Vdout1_102ck50 = 0.9 time = 255
.meas tran vdout1_102ck50 FIND v(dout1_102) AT=255.025n

* CHECK dout1_103 Vdout1_103ck50 = 0.9 time = 255
.meas tran vdout1_103ck50 FIND v(dout1_103) AT=255.025n

* CHECK dout1_104 Vdout1_104ck50 = 0 time = 255
.meas tran vdout1_104ck50 FIND v(dout1_104) AT=255.025n

* CHECK dout1_105 Vdout1_105ck50 = 0 time = 255
.meas tran vdout1_105ck50 FIND v(dout1_105) AT=255.025n

* CHECK dout1_106 Vdout1_106ck50 = 0.9 time = 255
.meas tran vdout1_106ck50 FIND v(dout1_106) AT=255.025n

* CHECK dout1_107 Vdout1_107ck50 = 0 time = 255
.meas tran vdout1_107ck50 FIND v(dout1_107) AT=255.025n

* CHECK dout1_108 Vdout1_108ck50 = 0 time = 255
.meas tran vdout1_108ck50 FIND v(dout1_108) AT=255.025n

* CHECK dout1_109 Vdout1_109ck50 = 0.9 time = 255
.meas tran vdout1_109ck50 FIND v(dout1_109) AT=255.025n

* CHECK dout1_110 Vdout1_110ck50 = 0 time = 255
.meas tran vdout1_110ck50 FIND v(dout1_110) AT=255.025n

* CHECK dout1_111 Vdout1_111ck50 = 0 time = 255
.meas tran vdout1_111ck50 FIND v(dout1_111) AT=255.025n

* CHECK dout1_112 Vdout1_112ck50 = 0 time = 255
.meas tran vdout1_112ck50 FIND v(dout1_112) AT=255.025n

* CHECK dout1_113 Vdout1_113ck50 = 0 time = 255
.meas tran vdout1_113ck50 FIND v(dout1_113) AT=255.025n

* CHECK dout1_114 Vdout1_114ck50 = 0.9 time = 255
.meas tran vdout1_114ck50 FIND v(dout1_114) AT=255.025n

* CHECK dout1_115 Vdout1_115ck50 = 0.9 time = 255
.meas tran vdout1_115ck50 FIND v(dout1_115) AT=255.025n

* CHECK dout1_116 Vdout1_116ck50 = 0 time = 255
.meas tran vdout1_116ck50 FIND v(dout1_116) AT=255.025n

* CHECK dout1_117 Vdout1_117ck50 = 0 time = 255
.meas tran vdout1_117ck50 FIND v(dout1_117) AT=255.025n

* CHECK dout1_118 Vdout1_118ck50 = 0 time = 255
.meas tran vdout1_118ck50 FIND v(dout1_118) AT=255.025n

* CHECK dout1_119 Vdout1_119ck50 = 0.9 time = 255
.meas tran vdout1_119ck50 FIND v(dout1_119) AT=255.025n

* CHECK dout1_0 Vdout1_0ck51 = 0.9 time = 260
.meas tran vdout1_0ck51 FIND v(dout1_0) AT=260.025n

* CHECK dout1_1 Vdout1_1ck51 = 0 time = 260
.meas tran vdout1_1ck51 FIND v(dout1_1) AT=260.025n

* CHECK dout1_2 Vdout1_2ck51 = 0.9 time = 260
.meas tran vdout1_2ck51 FIND v(dout1_2) AT=260.025n

* CHECK dout1_3 Vdout1_3ck51 = 0.9 time = 260
.meas tran vdout1_3ck51 FIND v(dout1_3) AT=260.025n

* CHECK dout1_4 Vdout1_4ck51 = 0 time = 260
.meas tran vdout1_4ck51 FIND v(dout1_4) AT=260.025n

* CHECK dout1_5 Vdout1_5ck51 = 0 time = 260
.meas tran vdout1_5ck51 FIND v(dout1_5) AT=260.025n

* CHECK dout1_6 Vdout1_6ck51 = 0.9 time = 260
.meas tran vdout1_6ck51 FIND v(dout1_6) AT=260.025n

* CHECK dout1_7 Vdout1_7ck51 = 0 time = 260
.meas tran vdout1_7ck51 FIND v(dout1_7) AT=260.025n

* CHECK dout1_8 Vdout1_8ck51 = 0 time = 260
.meas tran vdout1_8ck51 FIND v(dout1_8) AT=260.025n

* CHECK dout1_9 Vdout1_9ck51 = 0 time = 260
.meas tran vdout1_9ck51 FIND v(dout1_9) AT=260.025n

* CHECK dout1_10 Vdout1_10ck51 = 0 time = 260
.meas tran vdout1_10ck51 FIND v(dout1_10) AT=260.025n

* CHECK dout1_11 Vdout1_11ck51 = 0.9 time = 260
.meas tran vdout1_11ck51 FIND v(dout1_11) AT=260.025n

* CHECK dout1_12 Vdout1_12ck51 = 0 time = 260
.meas tran vdout1_12ck51 FIND v(dout1_12) AT=260.025n

* CHECK dout1_13 Vdout1_13ck51 = 0 time = 260
.meas tran vdout1_13ck51 FIND v(dout1_13) AT=260.025n

* CHECK dout1_14 Vdout1_14ck51 = 0.9 time = 260
.meas tran vdout1_14ck51 FIND v(dout1_14) AT=260.025n

* CHECK dout1_15 Vdout1_15ck51 = 0 time = 260
.meas tran vdout1_15ck51 FIND v(dout1_15) AT=260.025n

* CHECK dout1_16 Vdout1_16ck51 = 0.9 time = 260
.meas tran vdout1_16ck51 FIND v(dout1_16) AT=260.025n

* CHECK dout1_17 Vdout1_17ck51 = 0 time = 260
.meas tran vdout1_17ck51 FIND v(dout1_17) AT=260.025n

* CHECK dout1_18 Vdout1_18ck51 = 0.9 time = 260
.meas tran vdout1_18ck51 FIND v(dout1_18) AT=260.025n

* CHECK dout1_19 Vdout1_19ck51 = 0 time = 260
.meas tran vdout1_19ck51 FIND v(dout1_19) AT=260.025n

* CHECK dout1_20 Vdout1_20ck51 = 0.9 time = 260
.meas tran vdout1_20ck51 FIND v(dout1_20) AT=260.025n

* CHECK dout1_21 Vdout1_21ck51 = 0 time = 260
.meas tran vdout1_21ck51 FIND v(dout1_21) AT=260.025n

* CHECK dout1_22 Vdout1_22ck51 = 0 time = 260
.meas tran vdout1_22ck51 FIND v(dout1_22) AT=260.025n

* CHECK dout1_23 Vdout1_23ck51 = 0 time = 260
.meas tran vdout1_23ck51 FIND v(dout1_23) AT=260.025n

* CHECK dout1_24 Vdout1_24ck51 = 0.9 time = 260
.meas tran vdout1_24ck51 FIND v(dout1_24) AT=260.025n

* CHECK dout1_25 Vdout1_25ck51 = 0.9 time = 260
.meas tran vdout1_25ck51 FIND v(dout1_25) AT=260.025n

* CHECK dout1_26 Vdout1_26ck51 = 0 time = 260
.meas tran vdout1_26ck51 FIND v(dout1_26) AT=260.025n

* CHECK dout1_27 Vdout1_27ck51 = 0 time = 260
.meas tran vdout1_27ck51 FIND v(dout1_27) AT=260.025n

* CHECK dout1_28 Vdout1_28ck51 = 0 time = 260
.meas tran vdout1_28ck51 FIND v(dout1_28) AT=260.025n

* CHECK dout1_29 Vdout1_29ck51 = 0 time = 260
.meas tran vdout1_29ck51 FIND v(dout1_29) AT=260.025n

* CHECK dout1_30 Vdout1_30ck51 = 0 time = 260
.meas tran vdout1_30ck51 FIND v(dout1_30) AT=260.025n

* CHECK dout1_31 Vdout1_31ck51 = 0 time = 260
.meas tran vdout1_31ck51 FIND v(dout1_31) AT=260.025n

* CHECK dout1_32 Vdout1_32ck51 = 0 time = 260
.meas tran vdout1_32ck51 FIND v(dout1_32) AT=260.025n

* CHECK dout1_33 Vdout1_33ck51 = 0 time = 260
.meas tran vdout1_33ck51 FIND v(dout1_33) AT=260.025n

* CHECK dout1_34 Vdout1_34ck51 = 0.9 time = 260
.meas tran vdout1_34ck51 FIND v(dout1_34) AT=260.025n

* CHECK dout1_35 Vdout1_35ck51 = 0 time = 260
.meas tran vdout1_35ck51 FIND v(dout1_35) AT=260.025n

* CHECK dout1_36 Vdout1_36ck51 = 0 time = 260
.meas tran vdout1_36ck51 FIND v(dout1_36) AT=260.025n

* CHECK dout1_37 Vdout1_37ck51 = 0 time = 260
.meas tran vdout1_37ck51 FIND v(dout1_37) AT=260.025n

* CHECK dout1_38 Vdout1_38ck51 = 0 time = 260
.meas tran vdout1_38ck51 FIND v(dout1_38) AT=260.025n

* CHECK dout1_39 Vdout1_39ck51 = 0 time = 260
.meas tran vdout1_39ck51 FIND v(dout1_39) AT=260.025n

* CHECK dout1_40 Vdout1_40ck51 = 0.9 time = 260
.meas tran vdout1_40ck51 FIND v(dout1_40) AT=260.025n

* CHECK dout1_41 Vdout1_41ck51 = 0.9 time = 260
.meas tran vdout1_41ck51 FIND v(dout1_41) AT=260.025n

* CHECK dout1_42 Vdout1_42ck51 = 0 time = 260
.meas tran vdout1_42ck51 FIND v(dout1_42) AT=260.025n

* CHECK dout1_43 Vdout1_43ck51 = 0.9 time = 260
.meas tran vdout1_43ck51 FIND v(dout1_43) AT=260.025n

* CHECK dout1_44 Vdout1_44ck51 = 0.9 time = 260
.meas tran vdout1_44ck51 FIND v(dout1_44) AT=260.025n

* CHECK dout1_45 Vdout1_45ck51 = 0.9 time = 260
.meas tran vdout1_45ck51 FIND v(dout1_45) AT=260.025n

* CHECK dout1_46 Vdout1_46ck51 = 0 time = 260
.meas tran vdout1_46ck51 FIND v(dout1_46) AT=260.025n

* CHECK dout1_47 Vdout1_47ck51 = 0.9 time = 260
.meas tran vdout1_47ck51 FIND v(dout1_47) AT=260.025n

* CHECK dout1_48 Vdout1_48ck51 = 0.9 time = 260
.meas tran vdout1_48ck51 FIND v(dout1_48) AT=260.025n

* CHECK dout1_49 Vdout1_49ck51 = 0 time = 260
.meas tran vdout1_49ck51 FIND v(dout1_49) AT=260.025n

* CHECK dout1_50 Vdout1_50ck51 = 0.9 time = 260
.meas tran vdout1_50ck51 FIND v(dout1_50) AT=260.025n

* CHECK dout1_51 Vdout1_51ck51 = 0 time = 260
.meas tran vdout1_51ck51 FIND v(dout1_51) AT=260.025n

* CHECK dout1_52 Vdout1_52ck51 = 0 time = 260
.meas tran vdout1_52ck51 FIND v(dout1_52) AT=260.025n

* CHECK dout1_53 Vdout1_53ck51 = 0 time = 260
.meas tran vdout1_53ck51 FIND v(dout1_53) AT=260.025n

* CHECK dout1_54 Vdout1_54ck51 = 0 time = 260
.meas tran vdout1_54ck51 FIND v(dout1_54) AT=260.025n

* CHECK dout1_55 Vdout1_55ck51 = 0.9 time = 260
.meas tran vdout1_55ck51 FIND v(dout1_55) AT=260.025n

* CHECK dout1_56 Vdout1_56ck51 = 0 time = 260
.meas tran vdout1_56ck51 FIND v(dout1_56) AT=260.025n

* CHECK dout1_57 Vdout1_57ck51 = 0 time = 260
.meas tran vdout1_57ck51 FIND v(dout1_57) AT=260.025n

* CHECK dout1_58 Vdout1_58ck51 = 0.9 time = 260
.meas tran vdout1_58ck51 FIND v(dout1_58) AT=260.025n

* CHECK dout1_59 Vdout1_59ck51 = 0.9 time = 260
.meas tran vdout1_59ck51 FIND v(dout1_59) AT=260.025n

* CHECK dout1_60 Vdout1_60ck51 = 0.9 time = 260
.meas tran vdout1_60ck51 FIND v(dout1_60) AT=260.025n

* CHECK dout1_61 Vdout1_61ck51 = 0.9 time = 260
.meas tran vdout1_61ck51 FIND v(dout1_61) AT=260.025n

* CHECK dout1_62 Vdout1_62ck51 = 0 time = 260
.meas tran vdout1_62ck51 FIND v(dout1_62) AT=260.025n

* CHECK dout1_63 Vdout1_63ck51 = 0 time = 260
.meas tran vdout1_63ck51 FIND v(dout1_63) AT=260.025n

* CHECK dout1_64 Vdout1_64ck51 = 0 time = 260
.meas tran vdout1_64ck51 FIND v(dout1_64) AT=260.025n

* CHECK dout1_65 Vdout1_65ck51 = 0 time = 260
.meas tran vdout1_65ck51 FIND v(dout1_65) AT=260.025n

* CHECK dout1_66 Vdout1_66ck51 = 0 time = 260
.meas tran vdout1_66ck51 FIND v(dout1_66) AT=260.025n

* CHECK dout1_67 Vdout1_67ck51 = 0.9 time = 260
.meas tran vdout1_67ck51 FIND v(dout1_67) AT=260.025n

* CHECK dout1_68 Vdout1_68ck51 = 0.9 time = 260
.meas tran vdout1_68ck51 FIND v(dout1_68) AT=260.025n

* CHECK dout1_69 Vdout1_69ck51 = 0 time = 260
.meas tran vdout1_69ck51 FIND v(dout1_69) AT=260.025n

* CHECK dout1_70 Vdout1_70ck51 = 0 time = 260
.meas tran vdout1_70ck51 FIND v(dout1_70) AT=260.025n

* CHECK dout1_71 Vdout1_71ck51 = 0 time = 260
.meas tran vdout1_71ck51 FIND v(dout1_71) AT=260.025n

* CHECK dout1_72 Vdout1_72ck51 = 0 time = 260
.meas tran vdout1_72ck51 FIND v(dout1_72) AT=260.025n

* CHECK dout1_73 Vdout1_73ck51 = 0.9 time = 260
.meas tran vdout1_73ck51 FIND v(dout1_73) AT=260.025n

* CHECK dout1_74 Vdout1_74ck51 = 0.9 time = 260
.meas tran vdout1_74ck51 FIND v(dout1_74) AT=260.025n

* CHECK dout1_75 Vdout1_75ck51 = 0 time = 260
.meas tran vdout1_75ck51 FIND v(dout1_75) AT=260.025n

* CHECK dout1_76 Vdout1_76ck51 = 0 time = 260
.meas tran vdout1_76ck51 FIND v(dout1_76) AT=260.025n

* CHECK dout1_77 Vdout1_77ck51 = 0.9 time = 260
.meas tran vdout1_77ck51 FIND v(dout1_77) AT=260.025n

* CHECK dout1_78 Vdout1_78ck51 = 0 time = 260
.meas tran vdout1_78ck51 FIND v(dout1_78) AT=260.025n

* CHECK dout1_79 Vdout1_79ck51 = 0.9 time = 260
.meas tran vdout1_79ck51 FIND v(dout1_79) AT=260.025n

* CHECK dout1_80 Vdout1_80ck51 = 0 time = 260
.meas tran vdout1_80ck51 FIND v(dout1_80) AT=260.025n

* CHECK dout1_81 Vdout1_81ck51 = 0 time = 260
.meas tran vdout1_81ck51 FIND v(dout1_81) AT=260.025n

* CHECK dout1_82 Vdout1_82ck51 = 0.9 time = 260
.meas tran vdout1_82ck51 FIND v(dout1_82) AT=260.025n

* CHECK dout1_83 Vdout1_83ck51 = 0 time = 260
.meas tran vdout1_83ck51 FIND v(dout1_83) AT=260.025n

* CHECK dout1_84 Vdout1_84ck51 = 0 time = 260
.meas tran vdout1_84ck51 FIND v(dout1_84) AT=260.025n

* CHECK dout1_85 Vdout1_85ck51 = 0 time = 260
.meas tran vdout1_85ck51 FIND v(dout1_85) AT=260.025n

* CHECK dout1_86 Vdout1_86ck51 = 0.9 time = 260
.meas tran vdout1_86ck51 FIND v(dout1_86) AT=260.025n

* CHECK dout1_87 Vdout1_87ck51 = 0.9 time = 260
.meas tran vdout1_87ck51 FIND v(dout1_87) AT=260.025n

* CHECK dout1_88 Vdout1_88ck51 = 0.9 time = 260
.meas tran vdout1_88ck51 FIND v(dout1_88) AT=260.025n

* CHECK dout1_89 Vdout1_89ck51 = 0.9 time = 260
.meas tran vdout1_89ck51 FIND v(dout1_89) AT=260.025n

* CHECK dout1_90 Vdout1_90ck51 = 0 time = 260
.meas tran vdout1_90ck51 FIND v(dout1_90) AT=260.025n

* CHECK dout1_91 Vdout1_91ck51 = 0 time = 260
.meas tran vdout1_91ck51 FIND v(dout1_91) AT=260.025n

* CHECK dout1_92 Vdout1_92ck51 = 0.9 time = 260
.meas tran vdout1_92ck51 FIND v(dout1_92) AT=260.025n

* CHECK dout1_93 Vdout1_93ck51 = 0 time = 260
.meas tran vdout1_93ck51 FIND v(dout1_93) AT=260.025n

* CHECK dout1_94 Vdout1_94ck51 = 0.9 time = 260
.meas tran vdout1_94ck51 FIND v(dout1_94) AT=260.025n

* CHECK dout1_95 Vdout1_95ck51 = 0 time = 260
.meas tran vdout1_95ck51 FIND v(dout1_95) AT=260.025n

* CHECK dout1_96 Vdout1_96ck51 = 0.9 time = 260
.meas tran vdout1_96ck51 FIND v(dout1_96) AT=260.025n

* CHECK dout1_97 Vdout1_97ck51 = 0 time = 260
.meas tran vdout1_97ck51 FIND v(dout1_97) AT=260.025n

* CHECK dout1_98 Vdout1_98ck51 = 0 time = 260
.meas tran vdout1_98ck51 FIND v(dout1_98) AT=260.025n

* CHECK dout1_99 Vdout1_99ck51 = 0 time = 260
.meas tran vdout1_99ck51 FIND v(dout1_99) AT=260.025n

* CHECK dout1_100 Vdout1_100ck51 = 0.9 time = 260
.meas tran vdout1_100ck51 FIND v(dout1_100) AT=260.025n

* CHECK dout1_101 Vdout1_101ck51 = 0 time = 260
.meas tran vdout1_101ck51 FIND v(dout1_101) AT=260.025n

* CHECK dout1_102 Vdout1_102ck51 = 0 time = 260
.meas tran vdout1_102ck51 FIND v(dout1_102) AT=260.025n

* CHECK dout1_103 Vdout1_103ck51 = 0.9 time = 260
.meas tran vdout1_103ck51 FIND v(dout1_103) AT=260.025n

* CHECK dout1_104 Vdout1_104ck51 = 0 time = 260
.meas tran vdout1_104ck51 FIND v(dout1_104) AT=260.025n

* CHECK dout1_105 Vdout1_105ck51 = 0.9 time = 260
.meas tran vdout1_105ck51 FIND v(dout1_105) AT=260.025n

* CHECK dout1_106 Vdout1_106ck51 = 0 time = 260
.meas tran vdout1_106ck51 FIND v(dout1_106) AT=260.025n

* CHECK dout1_107 Vdout1_107ck51 = 0 time = 260
.meas tran vdout1_107ck51 FIND v(dout1_107) AT=260.025n

* CHECK dout1_108 Vdout1_108ck51 = 0 time = 260
.meas tran vdout1_108ck51 FIND v(dout1_108) AT=260.025n

* CHECK dout1_109 Vdout1_109ck51 = 0 time = 260
.meas tran vdout1_109ck51 FIND v(dout1_109) AT=260.025n

* CHECK dout1_110 Vdout1_110ck51 = 0 time = 260
.meas tran vdout1_110ck51 FIND v(dout1_110) AT=260.025n

* CHECK dout1_111 Vdout1_111ck51 = 0.9 time = 260
.meas tran vdout1_111ck51 FIND v(dout1_111) AT=260.025n

* CHECK dout1_112 Vdout1_112ck51 = 0 time = 260
.meas tran vdout1_112ck51 FIND v(dout1_112) AT=260.025n

* CHECK dout1_113 Vdout1_113ck51 = 0.9 time = 260
.meas tran vdout1_113ck51 FIND v(dout1_113) AT=260.025n

* CHECK dout1_114 Vdout1_114ck51 = 0 time = 260
.meas tran vdout1_114ck51 FIND v(dout1_114) AT=260.025n

* CHECK dout1_115 Vdout1_115ck51 = 0 time = 260
.meas tran vdout1_115ck51 FIND v(dout1_115) AT=260.025n

* CHECK dout1_116 Vdout1_116ck51 = 0.9 time = 260
.meas tran vdout1_116ck51 FIND v(dout1_116) AT=260.025n

* CHECK dout1_117 Vdout1_117ck51 = 0 time = 260
.meas tran vdout1_117ck51 FIND v(dout1_117) AT=260.025n

* CHECK dout1_118 Vdout1_118ck51 = 0 time = 260
.meas tran vdout1_118ck51 FIND v(dout1_118) AT=260.025n

* CHECK dout1_119 Vdout1_119ck51 = 0 time = 260
.meas tran vdout1_119ck51 FIND v(dout1_119) AT=260.025n

* CHECK dout1_0 Vdout1_0ck53 = 0.9 time = 270
.meas tran vdout1_0ck53 FIND v(dout1_0) AT=270.025n

* CHECK dout1_1 Vdout1_1ck53 = 0 time = 270
.meas tran vdout1_1ck53 FIND v(dout1_1) AT=270.025n

* CHECK dout1_2 Vdout1_2ck53 = 0.9 time = 270
.meas tran vdout1_2ck53 FIND v(dout1_2) AT=270.025n

* CHECK dout1_3 Vdout1_3ck53 = 0.9 time = 270
.meas tran vdout1_3ck53 FIND v(dout1_3) AT=270.025n

* CHECK dout1_4 Vdout1_4ck53 = 0 time = 270
.meas tran vdout1_4ck53 FIND v(dout1_4) AT=270.025n

* CHECK dout1_5 Vdout1_5ck53 = 0 time = 270
.meas tran vdout1_5ck53 FIND v(dout1_5) AT=270.025n

* CHECK dout1_6 Vdout1_6ck53 = 0.9 time = 270
.meas tran vdout1_6ck53 FIND v(dout1_6) AT=270.025n

* CHECK dout1_7 Vdout1_7ck53 = 0 time = 270
.meas tran vdout1_7ck53 FIND v(dout1_7) AT=270.025n

* CHECK dout1_8 Vdout1_8ck53 = 0 time = 270
.meas tran vdout1_8ck53 FIND v(dout1_8) AT=270.025n

* CHECK dout1_9 Vdout1_9ck53 = 0 time = 270
.meas tran vdout1_9ck53 FIND v(dout1_9) AT=270.025n

* CHECK dout1_10 Vdout1_10ck53 = 0 time = 270
.meas tran vdout1_10ck53 FIND v(dout1_10) AT=270.025n

* CHECK dout1_11 Vdout1_11ck53 = 0.9 time = 270
.meas tran vdout1_11ck53 FIND v(dout1_11) AT=270.025n

* CHECK dout1_12 Vdout1_12ck53 = 0 time = 270
.meas tran vdout1_12ck53 FIND v(dout1_12) AT=270.025n

* CHECK dout1_13 Vdout1_13ck53 = 0 time = 270
.meas tran vdout1_13ck53 FIND v(dout1_13) AT=270.025n

* CHECK dout1_14 Vdout1_14ck53 = 0.9 time = 270
.meas tran vdout1_14ck53 FIND v(dout1_14) AT=270.025n

* CHECK dout1_15 Vdout1_15ck53 = 0 time = 270
.meas tran vdout1_15ck53 FIND v(dout1_15) AT=270.025n

* CHECK dout1_16 Vdout1_16ck53 = 0.9 time = 270
.meas tran vdout1_16ck53 FIND v(dout1_16) AT=270.025n

* CHECK dout1_17 Vdout1_17ck53 = 0 time = 270
.meas tran vdout1_17ck53 FIND v(dout1_17) AT=270.025n

* CHECK dout1_18 Vdout1_18ck53 = 0.9 time = 270
.meas tran vdout1_18ck53 FIND v(dout1_18) AT=270.025n

* CHECK dout1_19 Vdout1_19ck53 = 0 time = 270
.meas tran vdout1_19ck53 FIND v(dout1_19) AT=270.025n

* CHECK dout1_20 Vdout1_20ck53 = 0.9 time = 270
.meas tran vdout1_20ck53 FIND v(dout1_20) AT=270.025n

* CHECK dout1_21 Vdout1_21ck53 = 0 time = 270
.meas tran vdout1_21ck53 FIND v(dout1_21) AT=270.025n

* CHECK dout1_22 Vdout1_22ck53 = 0 time = 270
.meas tran vdout1_22ck53 FIND v(dout1_22) AT=270.025n

* CHECK dout1_23 Vdout1_23ck53 = 0 time = 270
.meas tran vdout1_23ck53 FIND v(dout1_23) AT=270.025n

* CHECK dout1_24 Vdout1_24ck53 = 0.9 time = 270
.meas tran vdout1_24ck53 FIND v(dout1_24) AT=270.025n

* CHECK dout1_25 Vdout1_25ck53 = 0.9 time = 270
.meas tran vdout1_25ck53 FIND v(dout1_25) AT=270.025n

* CHECK dout1_26 Vdout1_26ck53 = 0 time = 270
.meas tran vdout1_26ck53 FIND v(dout1_26) AT=270.025n

* CHECK dout1_27 Vdout1_27ck53 = 0 time = 270
.meas tran vdout1_27ck53 FIND v(dout1_27) AT=270.025n

* CHECK dout1_28 Vdout1_28ck53 = 0 time = 270
.meas tran vdout1_28ck53 FIND v(dout1_28) AT=270.025n

* CHECK dout1_29 Vdout1_29ck53 = 0 time = 270
.meas tran vdout1_29ck53 FIND v(dout1_29) AT=270.025n

* CHECK dout1_30 Vdout1_30ck53 = 0 time = 270
.meas tran vdout1_30ck53 FIND v(dout1_30) AT=270.025n

* CHECK dout1_31 Vdout1_31ck53 = 0 time = 270
.meas tran vdout1_31ck53 FIND v(dout1_31) AT=270.025n

* CHECK dout1_32 Vdout1_32ck53 = 0 time = 270
.meas tran vdout1_32ck53 FIND v(dout1_32) AT=270.025n

* CHECK dout1_33 Vdout1_33ck53 = 0 time = 270
.meas tran vdout1_33ck53 FIND v(dout1_33) AT=270.025n

* CHECK dout1_34 Vdout1_34ck53 = 0.9 time = 270
.meas tran vdout1_34ck53 FIND v(dout1_34) AT=270.025n

* CHECK dout1_35 Vdout1_35ck53 = 0 time = 270
.meas tran vdout1_35ck53 FIND v(dout1_35) AT=270.025n

* CHECK dout1_36 Vdout1_36ck53 = 0 time = 270
.meas tran vdout1_36ck53 FIND v(dout1_36) AT=270.025n

* CHECK dout1_37 Vdout1_37ck53 = 0 time = 270
.meas tran vdout1_37ck53 FIND v(dout1_37) AT=270.025n

* CHECK dout1_38 Vdout1_38ck53 = 0 time = 270
.meas tran vdout1_38ck53 FIND v(dout1_38) AT=270.025n

* CHECK dout1_39 Vdout1_39ck53 = 0 time = 270
.meas tran vdout1_39ck53 FIND v(dout1_39) AT=270.025n

* CHECK dout1_40 Vdout1_40ck53 = 0.9 time = 270
.meas tran vdout1_40ck53 FIND v(dout1_40) AT=270.025n

* CHECK dout1_41 Vdout1_41ck53 = 0.9 time = 270
.meas tran vdout1_41ck53 FIND v(dout1_41) AT=270.025n

* CHECK dout1_42 Vdout1_42ck53 = 0 time = 270
.meas tran vdout1_42ck53 FIND v(dout1_42) AT=270.025n

* CHECK dout1_43 Vdout1_43ck53 = 0.9 time = 270
.meas tran vdout1_43ck53 FIND v(dout1_43) AT=270.025n

* CHECK dout1_44 Vdout1_44ck53 = 0.9 time = 270
.meas tran vdout1_44ck53 FIND v(dout1_44) AT=270.025n

* CHECK dout1_45 Vdout1_45ck53 = 0.9 time = 270
.meas tran vdout1_45ck53 FIND v(dout1_45) AT=270.025n

* CHECK dout1_46 Vdout1_46ck53 = 0 time = 270
.meas tran vdout1_46ck53 FIND v(dout1_46) AT=270.025n

* CHECK dout1_47 Vdout1_47ck53 = 0.9 time = 270
.meas tran vdout1_47ck53 FIND v(dout1_47) AT=270.025n

* CHECK dout1_48 Vdout1_48ck53 = 0.9 time = 270
.meas tran vdout1_48ck53 FIND v(dout1_48) AT=270.025n

* CHECK dout1_49 Vdout1_49ck53 = 0 time = 270
.meas tran vdout1_49ck53 FIND v(dout1_49) AT=270.025n

* CHECK dout1_50 Vdout1_50ck53 = 0.9 time = 270
.meas tran vdout1_50ck53 FIND v(dout1_50) AT=270.025n

* CHECK dout1_51 Vdout1_51ck53 = 0 time = 270
.meas tran vdout1_51ck53 FIND v(dout1_51) AT=270.025n

* CHECK dout1_52 Vdout1_52ck53 = 0 time = 270
.meas tran vdout1_52ck53 FIND v(dout1_52) AT=270.025n

* CHECK dout1_53 Vdout1_53ck53 = 0 time = 270
.meas tran vdout1_53ck53 FIND v(dout1_53) AT=270.025n

* CHECK dout1_54 Vdout1_54ck53 = 0 time = 270
.meas tran vdout1_54ck53 FIND v(dout1_54) AT=270.025n

* CHECK dout1_55 Vdout1_55ck53 = 0.9 time = 270
.meas tran vdout1_55ck53 FIND v(dout1_55) AT=270.025n

* CHECK dout1_56 Vdout1_56ck53 = 0 time = 270
.meas tran vdout1_56ck53 FIND v(dout1_56) AT=270.025n

* CHECK dout1_57 Vdout1_57ck53 = 0 time = 270
.meas tran vdout1_57ck53 FIND v(dout1_57) AT=270.025n

* CHECK dout1_58 Vdout1_58ck53 = 0.9 time = 270
.meas tran vdout1_58ck53 FIND v(dout1_58) AT=270.025n

* CHECK dout1_59 Vdout1_59ck53 = 0.9 time = 270
.meas tran vdout1_59ck53 FIND v(dout1_59) AT=270.025n

* CHECK dout1_60 Vdout1_60ck53 = 0.9 time = 270
.meas tran vdout1_60ck53 FIND v(dout1_60) AT=270.025n

* CHECK dout1_61 Vdout1_61ck53 = 0.9 time = 270
.meas tran vdout1_61ck53 FIND v(dout1_61) AT=270.025n

* CHECK dout1_62 Vdout1_62ck53 = 0 time = 270
.meas tran vdout1_62ck53 FIND v(dout1_62) AT=270.025n

* CHECK dout1_63 Vdout1_63ck53 = 0 time = 270
.meas tran vdout1_63ck53 FIND v(dout1_63) AT=270.025n

* CHECK dout1_64 Vdout1_64ck53 = 0 time = 270
.meas tran vdout1_64ck53 FIND v(dout1_64) AT=270.025n

* CHECK dout1_65 Vdout1_65ck53 = 0 time = 270
.meas tran vdout1_65ck53 FIND v(dout1_65) AT=270.025n

* CHECK dout1_66 Vdout1_66ck53 = 0 time = 270
.meas tran vdout1_66ck53 FIND v(dout1_66) AT=270.025n

* CHECK dout1_67 Vdout1_67ck53 = 0.9 time = 270
.meas tran vdout1_67ck53 FIND v(dout1_67) AT=270.025n

* CHECK dout1_68 Vdout1_68ck53 = 0.9 time = 270
.meas tran vdout1_68ck53 FIND v(dout1_68) AT=270.025n

* CHECK dout1_69 Vdout1_69ck53 = 0 time = 270
.meas tran vdout1_69ck53 FIND v(dout1_69) AT=270.025n

* CHECK dout1_70 Vdout1_70ck53 = 0 time = 270
.meas tran vdout1_70ck53 FIND v(dout1_70) AT=270.025n

* CHECK dout1_71 Vdout1_71ck53 = 0 time = 270
.meas tran vdout1_71ck53 FIND v(dout1_71) AT=270.025n

* CHECK dout1_72 Vdout1_72ck53 = 0 time = 270
.meas tran vdout1_72ck53 FIND v(dout1_72) AT=270.025n

* CHECK dout1_73 Vdout1_73ck53 = 0.9 time = 270
.meas tran vdout1_73ck53 FIND v(dout1_73) AT=270.025n

* CHECK dout1_74 Vdout1_74ck53 = 0.9 time = 270
.meas tran vdout1_74ck53 FIND v(dout1_74) AT=270.025n

* CHECK dout1_75 Vdout1_75ck53 = 0 time = 270
.meas tran vdout1_75ck53 FIND v(dout1_75) AT=270.025n

* CHECK dout1_76 Vdout1_76ck53 = 0 time = 270
.meas tran vdout1_76ck53 FIND v(dout1_76) AT=270.025n

* CHECK dout1_77 Vdout1_77ck53 = 0.9 time = 270
.meas tran vdout1_77ck53 FIND v(dout1_77) AT=270.025n

* CHECK dout1_78 Vdout1_78ck53 = 0 time = 270
.meas tran vdout1_78ck53 FIND v(dout1_78) AT=270.025n

* CHECK dout1_79 Vdout1_79ck53 = 0.9 time = 270
.meas tran vdout1_79ck53 FIND v(dout1_79) AT=270.025n

* CHECK dout1_80 Vdout1_80ck53 = 0 time = 270
.meas tran vdout1_80ck53 FIND v(dout1_80) AT=270.025n

* CHECK dout1_81 Vdout1_81ck53 = 0 time = 270
.meas tran vdout1_81ck53 FIND v(dout1_81) AT=270.025n

* CHECK dout1_82 Vdout1_82ck53 = 0.9 time = 270
.meas tran vdout1_82ck53 FIND v(dout1_82) AT=270.025n

* CHECK dout1_83 Vdout1_83ck53 = 0 time = 270
.meas tran vdout1_83ck53 FIND v(dout1_83) AT=270.025n

* CHECK dout1_84 Vdout1_84ck53 = 0 time = 270
.meas tran vdout1_84ck53 FIND v(dout1_84) AT=270.025n

* CHECK dout1_85 Vdout1_85ck53 = 0 time = 270
.meas tran vdout1_85ck53 FIND v(dout1_85) AT=270.025n

* CHECK dout1_86 Vdout1_86ck53 = 0.9 time = 270
.meas tran vdout1_86ck53 FIND v(dout1_86) AT=270.025n

* CHECK dout1_87 Vdout1_87ck53 = 0.9 time = 270
.meas tran vdout1_87ck53 FIND v(dout1_87) AT=270.025n

* CHECK dout1_88 Vdout1_88ck53 = 0.9 time = 270
.meas tran vdout1_88ck53 FIND v(dout1_88) AT=270.025n

* CHECK dout1_89 Vdout1_89ck53 = 0.9 time = 270
.meas tran vdout1_89ck53 FIND v(dout1_89) AT=270.025n

* CHECK dout1_90 Vdout1_90ck53 = 0 time = 270
.meas tran vdout1_90ck53 FIND v(dout1_90) AT=270.025n

* CHECK dout1_91 Vdout1_91ck53 = 0 time = 270
.meas tran vdout1_91ck53 FIND v(dout1_91) AT=270.025n

* CHECK dout1_92 Vdout1_92ck53 = 0.9 time = 270
.meas tran vdout1_92ck53 FIND v(dout1_92) AT=270.025n

* CHECK dout1_93 Vdout1_93ck53 = 0 time = 270
.meas tran vdout1_93ck53 FIND v(dout1_93) AT=270.025n

* CHECK dout1_94 Vdout1_94ck53 = 0.9 time = 270
.meas tran vdout1_94ck53 FIND v(dout1_94) AT=270.025n

* CHECK dout1_95 Vdout1_95ck53 = 0 time = 270
.meas tran vdout1_95ck53 FIND v(dout1_95) AT=270.025n

* CHECK dout1_96 Vdout1_96ck53 = 0.9 time = 270
.meas tran vdout1_96ck53 FIND v(dout1_96) AT=270.025n

* CHECK dout1_97 Vdout1_97ck53 = 0 time = 270
.meas tran vdout1_97ck53 FIND v(dout1_97) AT=270.025n

* CHECK dout1_98 Vdout1_98ck53 = 0 time = 270
.meas tran vdout1_98ck53 FIND v(dout1_98) AT=270.025n

* CHECK dout1_99 Vdout1_99ck53 = 0 time = 270
.meas tran vdout1_99ck53 FIND v(dout1_99) AT=270.025n

* CHECK dout1_100 Vdout1_100ck53 = 0.9 time = 270
.meas tran vdout1_100ck53 FIND v(dout1_100) AT=270.025n

* CHECK dout1_101 Vdout1_101ck53 = 0 time = 270
.meas tran vdout1_101ck53 FIND v(dout1_101) AT=270.025n

* CHECK dout1_102 Vdout1_102ck53 = 0 time = 270
.meas tran vdout1_102ck53 FIND v(dout1_102) AT=270.025n

* CHECK dout1_103 Vdout1_103ck53 = 0.9 time = 270
.meas tran vdout1_103ck53 FIND v(dout1_103) AT=270.025n

* CHECK dout1_104 Vdout1_104ck53 = 0 time = 270
.meas tran vdout1_104ck53 FIND v(dout1_104) AT=270.025n

* CHECK dout1_105 Vdout1_105ck53 = 0.9 time = 270
.meas tran vdout1_105ck53 FIND v(dout1_105) AT=270.025n

* CHECK dout1_106 Vdout1_106ck53 = 0 time = 270
.meas tran vdout1_106ck53 FIND v(dout1_106) AT=270.025n

* CHECK dout1_107 Vdout1_107ck53 = 0 time = 270
.meas tran vdout1_107ck53 FIND v(dout1_107) AT=270.025n

* CHECK dout1_108 Vdout1_108ck53 = 0 time = 270
.meas tran vdout1_108ck53 FIND v(dout1_108) AT=270.025n

* CHECK dout1_109 Vdout1_109ck53 = 0 time = 270
.meas tran vdout1_109ck53 FIND v(dout1_109) AT=270.025n

* CHECK dout1_110 Vdout1_110ck53 = 0 time = 270
.meas tran vdout1_110ck53 FIND v(dout1_110) AT=270.025n

* CHECK dout1_111 Vdout1_111ck53 = 0.9 time = 270
.meas tran vdout1_111ck53 FIND v(dout1_111) AT=270.025n

* CHECK dout1_112 Vdout1_112ck53 = 0 time = 270
.meas tran vdout1_112ck53 FIND v(dout1_112) AT=270.025n

* CHECK dout1_113 Vdout1_113ck53 = 0.9 time = 270
.meas tran vdout1_113ck53 FIND v(dout1_113) AT=270.025n

* CHECK dout1_114 Vdout1_114ck53 = 0 time = 270
.meas tran vdout1_114ck53 FIND v(dout1_114) AT=270.025n

* CHECK dout1_115 Vdout1_115ck53 = 0 time = 270
.meas tran vdout1_115ck53 FIND v(dout1_115) AT=270.025n

* CHECK dout1_116 Vdout1_116ck53 = 0.9 time = 270
.meas tran vdout1_116ck53 FIND v(dout1_116) AT=270.025n

* CHECK dout1_117 Vdout1_117ck53 = 0 time = 270
.meas tran vdout1_117ck53 FIND v(dout1_117) AT=270.025n

* CHECK dout1_118 Vdout1_118ck53 = 0 time = 270
.meas tran vdout1_118ck53 FIND v(dout1_118) AT=270.025n

* CHECK dout1_119 Vdout1_119ck53 = 0 time = 270
.meas tran vdout1_119ck53 FIND v(dout1_119) AT=270.025n

* CHECK dout1_0 Vdout1_0ck62 = 0 time = 315
.meas tran vdout1_0ck62 FIND v(dout1_0) AT=315.025n

* CHECK dout1_1 Vdout1_1ck62 = 0 time = 315
.meas tran vdout1_1ck62 FIND v(dout1_1) AT=315.025n

* CHECK dout1_2 Vdout1_2ck62 = 0 time = 315
.meas tran vdout1_2ck62 FIND v(dout1_2) AT=315.025n

* CHECK dout1_3 Vdout1_3ck62 = 0.9 time = 315
.meas tran vdout1_3ck62 FIND v(dout1_3) AT=315.025n

* CHECK dout1_4 Vdout1_4ck62 = 0 time = 315
.meas tran vdout1_4ck62 FIND v(dout1_4) AT=315.025n

* CHECK dout1_5 Vdout1_5ck62 = 0 time = 315
.meas tran vdout1_5ck62 FIND v(dout1_5) AT=315.025n

* CHECK dout1_6 Vdout1_6ck62 = 0.9 time = 315
.meas tran vdout1_6ck62 FIND v(dout1_6) AT=315.025n

* CHECK dout1_7 Vdout1_7ck62 = 0.9 time = 315
.meas tran vdout1_7ck62 FIND v(dout1_7) AT=315.025n

* CHECK dout1_8 Vdout1_8ck62 = 0 time = 315
.meas tran vdout1_8ck62 FIND v(dout1_8) AT=315.025n

* CHECK dout1_9 Vdout1_9ck62 = 0.9 time = 315
.meas tran vdout1_9ck62 FIND v(dout1_9) AT=315.025n

* CHECK dout1_10 Vdout1_10ck62 = 0.9 time = 315
.meas tran vdout1_10ck62 FIND v(dout1_10) AT=315.025n

* CHECK dout1_11 Vdout1_11ck62 = 0.9 time = 315
.meas tran vdout1_11ck62 FIND v(dout1_11) AT=315.025n

* CHECK dout1_12 Vdout1_12ck62 = 0 time = 315
.meas tran vdout1_12ck62 FIND v(dout1_12) AT=315.025n

* CHECK dout1_13 Vdout1_13ck62 = 0 time = 315
.meas tran vdout1_13ck62 FIND v(dout1_13) AT=315.025n

* CHECK dout1_14 Vdout1_14ck62 = 0.9 time = 315
.meas tran vdout1_14ck62 FIND v(dout1_14) AT=315.025n

* CHECK dout1_15 Vdout1_15ck62 = 0 time = 315
.meas tran vdout1_15ck62 FIND v(dout1_15) AT=315.025n

* CHECK dout1_16 Vdout1_16ck62 = 0 time = 315
.meas tran vdout1_16ck62 FIND v(dout1_16) AT=315.025n

* CHECK dout1_17 Vdout1_17ck62 = 0.9 time = 315
.meas tran vdout1_17ck62 FIND v(dout1_17) AT=315.025n

* CHECK dout1_18 Vdout1_18ck62 = 0 time = 315
.meas tran vdout1_18ck62 FIND v(dout1_18) AT=315.025n

* CHECK dout1_19 Vdout1_19ck62 = 0 time = 315
.meas tran vdout1_19ck62 FIND v(dout1_19) AT=315.025n

* CHECK dout1_20 Vdout1_20ck62 = 0.9 time = 315
.meas tran vdout1_20ck62 FIND v(dout1_20) AT=315.025n

* CHECK dout1_21 Vdout1_21ck62 = 0.9 time = 315
.meas tran vdout1_21ck62 FIND v(dout1_21) AT=315.025n

* CHECK dout1_22 Vdout1_22ck62 = 0 time = 315
.meas tran vdout1_22ck62 FIND v(dout1_22) AT=315.025n

* CHECK dout1_23 Vdout1_23ck62 = 0.9 time = 315
.meas tran vdout1_23ck62 FIND v(dout1_23) AT=315.025n

* CHECK dout1_24 Vdout1_24ck62 = 0.9 time = 315
.meas tran vdout1_24ck62 FIND v(dout1_24) AT=315.025n

* CHECK dout1_25 Vdout1_25ck62 = 0.9 time = 315
.meas tran vdout1_25ck62 FIND v(dout1_25) AT=315.025n

* CHECK dout1_26 Vdout1_26ck62 = 0 time = 315
.meas tran vdout1_26ck62 FIND v(dout1_26) AT=315.025n

* CHECK dout1_27 Vdout1_27ck62 = 0.9 time = 315
.meas tran vdout1_27ck62 FIND v(dout1_27) AT=315.025n

* CHECK dout1_28 Vdout1_28ck62 = 0.9 time = 315
.meas tran vdout1_28ck62 FIND v(dout1_28) AT=315.025n

* CHECK dout1_29 Vdout1_29ck62 = 0 time = 315
.meas tran vdout1_29ck62 FIND v(dout1_29) AT=315.025n

* CHECK dout1_30 Vdout1_30ck62 = 0.9 time = 315
.meas tran vdout1_30ck62 FIND v(dout1_30) AT=315.025n

* CHECK dout1_31 Vdout1_31ck62 = 0 time = 315
.meas tran vdout1_31ck62 FIND v(dout1_31) AT=315.025n

* CHECK dout1_32 Vdout1_32ck62 = 0.9 time = 315
.meas tran vdout1_32ck62 FIND v(dout1_32) AT=315.025n

* CHECK dout1_33 Vdout1_33ck62 = 0 time = 315
.meas tran vdout1_33ck62 FIND v(dout1_33) AT=315.025n

* CHECK dout1_34 Vdout1_34ck62 = 0 time = 315
.meas tran vdout1_34ck62 FIND v(dout1_34) AT=315.025n

* CHECK dout1_35 Vdout1_35ck62 = 0.9 time = 315
.meas tran vdout1_35ck62 FIND v(dout1_35) AT=315.025n

* CHECK dout1_36 Vdout1_36ck62 = 0.9 time = 315
.meas tran vdout1_36ck62 FIND v(dout1_36) AT=315.025n

* CHECK dout1_37 Vdout1_37ck62 = 0 time = 315
.meas tran vdout1_37ck62 FIND v(dout1_37) AT=315.025n

* CHECK dout1_38 Vdout1_38ck62 = 0.9 time = 315
.meas tran vdout1_38ck62 FIND v(dout1_38) AT=315.025n

* CHECK dout1_39 Vdout1_39ck62 = 0 time = 315
.meas tran vdout1_39ck62 FIND v(dout1_39) AT=315.025n

* CHECK dout1_40 Vdout1_40ck62 = 0.9 time = 315
.meas tran vdout1_40ck62 FIND v(dout1_40) AT=315.025n

* CHECK dout1_41 Vdout1_41ck62 = 0 time = 315
.meas tran vdout1_41ck62 FIND v(dout1_41) AT=315.025n

* CHECK dout1_42 Vdout1_42ck62 = 0.9 time = 315
.meas tran vdout1_42ck62 FIND v(dout1_42) AT=315.025n

* CHECK dout1_43 Vdout1_43ck62 = 0.9 time = 315
.meas tran vdout1_43ck62 FIND v(dout1_43) AT=315.025n

* CHECK dout1_44 Vdout1_44ck62 = 0 time = 315
.meas tran vdout1_44ck62 FIND v(dout1_44) AT=315.025n

* CHECK dout1_45 Vdout1_45ck62 = 0 time = 315
.meas tran vdout1_45ck62 FIND v(dout1_45) AT=315.025n

* CHECK dout1_46 Vdout1_46ck62 = 0 time = 315
.meas tran vdout1_46ck62 FIND v(dout1_46) AT=315.025n

* CHECK dout1_47 Vdout1_47ck62 = 0.9 time = 315
.meas tran vdout1_47ck62 FIND v(dout1_47) AT=315.025n

* CHECK dout1_48 Vdout1_48ck62 = 0.9 time = 315
.meas tran vdout1_48ck62 FIND v(dout1_48) AT=315.025n

* CHECK dout1_49 Vdout1_49ck62 = 0.9 time = 315
.meas tran vdout1_49ck62 FIND v(dout1_49) AT=315.025n

* CHECK dout1_50 Vdout1_50ck62 = 0 time = 315
.meas tran vdout1_50ck62 FIND v(dout1_50) AT=315.025n

* CHECK dout1_51 Vdout1_51ck62 = 0.9 time = 315
.meas tran vdout1_51ck62 FIND v(dout1_51) AT=315.025n

* CHECK dout1_52 Vdout1_52ck62 = 0.9 time = 315
.meas tran vdout1_52ck62 FIND v(dout1_52) AT=315.025n

* CHECK dout1_53 Vdout1_53ck62 = 0.9 time = 315
.meas tran vdout1_53ck62 FIND v(dout1_53) AT=315.025n

* CHECK dout1_54 Vdout1_54ck62 = 0.9 time = 315
.meas tran vdout1_54ck62 FIND v(dout1_54) AT=315.025n

* CHECK dout1_55 Vdout1_55ck62 = 0.9 time = 315
.meas tran vdout1_55ck62 FIND v(dout1_55) AT=315.025n

* CHECK dout1_56 Vdout1_56ck62 = 0 time = 315
.meas tran vdout1_56ck62 FIND v(dout1_56) AT=315.025n

* CHECK dout1_57 Vdout1_57ck62 = 0 time = 315
.meas tran vdout1_57ck62 FIND v(dout1_57) AT=315.025n

* CHECK dout1_58 Vdout1_58ck62 = 0 time = 315
.meas tran vdout1_58ck62 FIND v(dout1_58) AT=315.025n

* CHECK dout1_59 Vdout1_59ck62 = 0.9 time = 315
.meas tran vdout1_59ck62 FIND v(dout1_59) AT=315.025n

* CHECK dout1_60 Vdout1_60ck62 = 0 time = 315
.meas tran vdout1_60ck62 FIND v(dout1_60) AT=315.025n

* CHECK dout1_61 Vdout1_61ck62 = 0 time = 315
.meas tran vdout1_61ck62 FIND v(dout1_61) AT=315.025n

* CHECK dout1_62 Vdout1_62ck62 = 0 time = 315
.meas tran vdout1_62ck62 FIND v(dout1_62) AT=315.025n

* CHECK dout1_63 Vdout1_63ck62 = 0 time = 315
.meas tran vdout1_63ck62 FIND v(dout1_63) AT=315.025n

* CHECK dout1_64 Vdout1_64ck62 = 0.9 time = 315
.meas tran vdout1_64ck62 FIND v(dout1_64) AT=315.025n

* CHECK dout1_65 Vdout1_65ck62 = 0.9 time = 315
.meas tran vdout1_65ck62 FIND v(dout1_65) AT=315.025n

* CHECK dout1_66 Vdout1_66ck62 = 0 time = 315
.meas tran vdout1_66ck62 FIND v(dout1_66) AT=315.025n

* CHECK dout1_67 Vdout1_67ck62 = 0.9 time = 315
.meas tran vdout1_67ck62 FIND v(dout1_67) AT=315.025n

* CHECK dout1_68 Vdout1_68ck62 = 0.9 time = 315
.meas tran vdout1_68ck62 FIND v(dout1_68) AT=315.025n

* CHECK dout1_69 Vdout1_69ck62 = 0.9 time = 315
.meas tran vdout1_69ck62 FIND v(dout1_69) AT=315.025n

* CHECK dout1_70 Vdout1_70ck62 = 0.9 time = 315
.meas tran vdout1_70ck62 FIND v(dout1_70) AT=315.025n

* CHECK dout1_71 Vdout1_71ck62 = 0.9 time = 315
.meas tran vdout1_71ck62 FIND v(dout1_71) AT=315.025n

* CHECK dout1_72 Vdout1_72ck62 = 0 time = 315
.meas tran vdout1_72ck62 FIND v(dout1_72) AT=315.025n

* CHECK dout1_73 Vdout1_73ck62 = 0 time = 315
.meas tran vdout1_73ck62 FIND v(dout1_73) AT=315.025n

* CHECK dout1_74 Vdout1_74ck62 = 0.9 time = 315
.meas tran vdout1_74ck62 FIND v(dout1_74) AT=315.025n

* CHECK dout1_75 Vdout1_75ck62 = 0.9 time = 315
.meas tran vdout1_75ck62 FIND v(dout1_75) AT=315.025n

* CHECK dout1_76 Vdout1_76ck62 = 0 time = 315
.meas tran vdout1_76ck62 FIND v(dout1_76) AT=315.025n

* CHECK dout1_77 Vdout1_77ck62 = 0 time = 315
.meas tran vdout1_77ck62 FIND v(dout1_77) AT=315.025n

* CHECK dout1_78 Vdout1_78ck62 = 0.9 time = 315
.meas tran vdout1_78ck62 FIND v(dout1_78) AT=315.025n

* CHECK dout1_79 Vdout1_79ck62 = 0 time = 315
.meas tran vdout1_79ck62 FIND v(dout1_79) AT=315.025n

* CHECK dout1_80 Vdout1_80ck62 = 0.9 time = 315
.meas tran vdout1_80ck62 FIND v(dout1_80) AT=315.025n

* CHECK dout1_81 Vdout1_81ck62 = 0 time = 315
.meas tran vdout1_81ck62 FIND v(dout1_81) AT=315.025n

* CHECK dout1_82 Vdout1_82ck62 = 0.9 time = 315
.meas tran vdout1_82ck62 FIND v(dout1_82) AT=315.025n

* CHECK dout1_83 Vdout1_83ck62 = 0 time = 315
.meas tran vdout1_83ck62 FIND v(dout1_83) AT=315.025n

* CHECK dout1_84 Vdout1_84ck62 = 0.9 time = 315
.meas tran vdout1_84ck62 FIND v(dout1_84) AT=315.025n

* CHECK dout1_85 Vdout1_85ck62 = 0 time = 315
.meas tran vdout1_85ck62 FIND v(dout1_85) AT=315.025n

* CHECK dout1_86 Vdout1_86ck62 = 0 time = 315
.meas tran vdout1_86ck62 FIND v(dout1_86) AT=315.025n

* CHECK dout1_87 Vdout1_87ck62 = 0.9 time = 315
.meas tran vdout1_87ck62 FIND v(dout1_87) AT=315.025n

* CHECK dout1_88 Vdout1_88ck62 = 0.9 time = 315
.meas tran vdout1_88ck62 FIND v(dout1_88) AT=315.025n

* CHECK dout1_89 Vdout1_89ck62 = 0 time = 315
.meas tran vdout1_89ck62 FIND v(dout1_89) AT=315.025n

* CHECK dout1_90 Vdout1_90ck62 = 0 time = 315
.meas tran vdout1_90ck62 FIND v(dout1_90) AT=315.025n

* CHECK dout1_91 Vdout1_91ck62 = 0.9 time = 315
.meas tran vdout1_91ck62 FIND v(dout1_91) AT=315.025n

* CHECK dout1_92 Vdout1_92ck62 = 0.9 time = 315
.meas tran vdout1_92ck62 FIND v(dout1_92) AT=315.025n

* CHECK dout1_93 Vdout1_93ck62 = 0.9 time = 315
.meas tran vdout1_93ck62 FIND v(dout1_93) AT=315.025n

* CHECK dout1_94 Vdout1_94ck62 = 0 time = 315
.meas tran vdout1_94ck62 FIND v(dout1_94) AT=315.025n

* CHECK dout1_95 Vdout1_95ck62 = 0.9 time = 315
.meas tran vdout1_95ck62 FIND v(dout1_95) AT=315.025n

* CHECK dout1_96 Vdout1_96ck62 = 0.9 time = 315
.meas tran vdout1_96ck62 FIND v(dout1_96) AT=315.025n

* CHECK dout1_97 Vdout1_97ck62 = 0.9 time = 315
.meas tran vdout1_97ck62 FIND v(dout1_97) AT=315.025n

* CHECK dout1_98 Vdout1_98ck62 = 0.9 time = 315
.meas tran vdout1_98ck62 FIND v(dout1_98) AT=315.025n

* CHECK dout1_99 Vdout1_99ck62 = 0 time = 315
.meas tran vdout1_99ck62 FIND v(dout1_99) AT=315.025n

* CHECK dout1_100 Vdout1_100ck62 = 0 time = 315
.meas tran vdout1_100ck62 FIND v(dout1_100) AT=315.025n

* CHECK dout1_101 Vdout1_101ck62 = 0.9 time = 315
.meas tran vdout1_101ck62 FIND v(dout1_101) AT=315.025n

* CHECK dout1_102 Vdout1_102ck62 = 0.9 time = 315
.meas tran vdout1_102ck62 FIND v(dout1_102) AT=315.025n

* CHECK dout1_103 Vdout1_103ck62 = 0 time = 315
.meas tran vdout1_103ck62 FIND v(dout1_103) AT=315.025n

* CHECK dout1_104 Vdout1_104ck62 = 0 time = 315
.meas tran vdout1_104ck62 FIND v(dout1_104) AT=315.025n

* CHECK dout1_105 Vdout1_105ck62 = 0 time = 315
.meas tran vdout1_105ck62 FIND v(dout1_105) AT=315.025n

* CHECK dout1_106 Vdout1_106ck62 = 0 time = 315
.meas tran vdout1_106ck62 FIND v(dout1_106) AT=315.025n

* CHECK dout1_107 Vdout1_107ck62 = 0.9 time = 315
.meas tran vdout1_107ck62 FIND v(dout1_107) AT=315.025n

* CHECK dout1_108 Vdout1_108ck62 = 0.9 time = 315
.meas tran vdout1_108ck62 FIND v(dout1_108) AT=315.025n

* CHECK dout1_109 Vdout1_109ck62 = 0 time = 315
.meas tran vdout1_109ck62 FIND v(dout1_109) AT=315.025n

* CHECK dout1_110 Vdout1_110ck62 = 0 time = 315
.meas tran vdout1_110ck62 FIND v(dout1_110) AT=315.025n

* CHECK dout1_111 Vdout1_111ck62 = 0.9 time = 315
.meas tran vdout1_111ck62 FIND v(dout1_111) AT=315.025n

* CHECK dout1_112 Vdout1_112ck62 = 0 time = 315
.meas tran vdout1_112ck62 FIND v(dout1_112) AT=315.025n

* CHECK dout1_113 Vdout1_113ck62 = 0 time = 315
.meas tran vdout1_113ck62 FIND v(dout1_113) AT=315.025n

* CHECK dout1_114 Vdout1_114ck62 = 0.9 time = 315
.meas tran vdout1_114ck62 FIND v(dout1_114) AT=315.025n

* CHECK dout1_115 Vdout1_115ck62 = 0.9 time = 315
.meas tran vdout1_115ck62 FIND v(dout1_115) AT=315.025n

* CHECK dout1_116 Vdout1_116ck62 = 0.9 time = 315
.meas tran vdout1_116ck62 FIND v(dout1_116) AT=315.025n

* CHECK dout1_117 Vdout1_117ck62 = 0.9 time = 315
.meas tran vdout1_117ck62 FIND v(dout1_117) AT=315.025n

* CHECK dout1_118 Vdout1_118ck62 = 0 time = 315
.meas tran vdout1_118ck62 FIND v(dout1_118) AT=315.025n

* CHECK dout1_119 Vdout1_119ck62 = 0 time = 315
.meas tran vdout1_119ck62 FIND v(dout1_119) AT=315.025n

* CHECK dout1_0 Vdout1_0ck65 = 0 time = 330
.meas tran vdout1_0ck65 FIND v(dout1_0) AT=330.025n

* CHECK dout1_1 Vdout1_1ck65 = 0 time = 330
.meas tran vdout1_1ck65 FIND v(dout1_1) AT=330.025n

* CHECK dout1_2 Vdout1_2ck65 = 0 time = 330
.meas tran vdout1_2ck65 FIND v(dout1_2) AT=330.025n

* CHECK dout1_3 Vdout1_3ck65 = 0 time = 330
.meas tran vdout1_3ck65 FIND v(dout1_3) AT=330.025n

* CHECK dout1_4 Vdout1_4ck65 = 0.9 time = 330
.meas tran vdout1_4ck65 FIND v(dout1_4) AT=330.025n

* CHECK dout1_5 Vdout1_5ck65 = 0 time = 330
.meas tran vdout1_5ck65 FIND v(dout1_5) AT=330.025n

* CHECK dout1_6 Vdout1_6ck65 = 0 time = 330
.meas tran vdout1_6ck65 FIND v(dout1_6) AT=330.025n

* CHECK dout1_7 Vdout1_7ck65 = 0.9 time = 330
.meas tran vdout1_7ck65 FIND v(dout1_7) AT=330.025n

* CHECK dout1_8 Vdout1_8ck65 = 0.9 time = 330
.meas tran vdout1_8ck65 FIND v(dout1_8) AT=330.025n

* CHECK dout1_9 Vdout1_9ck65 = 0.9 time = 330
.meas tran vdout1_9ck65 FIND v(dout1_9) AT=330.025n

* CHECK dout1_10 Vdout1_10ck65 = 0 time = 330
.meas tran vdout1_10ck65 FIND v(dout1_10) AT=330.025n

* CHECK dout1_11 Vdout1_11ck65 = 0.9 time = 330
.meas tran vdout1_11ck65 FIND v(dout1_11) AT=330.025n

* CHECK dout1_12 Vdout1_12ck65 = 0.9 time = 330
.meas tran vdout1_12ck65 FIND v(dout1_12) AT=330.025n

* CHECK dout1_13 Vdout1_13ck65 = 0 time = 330
.meas tran vdout1_13ck65 FIND v(dout1_13) AT=330.025n

* CHECK dout1_14 Vdout1_14ck65 = 0 time = 330
.meas tran vdout1_14ck65 FIND v(dout1_14) AT=330.025n

* CHECK dout1_15 Vdout1_15ck65 = 0.9 time = 330
.meas tran vdout1_15ck65 FIND v(dout1_15) AT=330.025n

* CHECK dout1_16 Vdout1_16ck65 = 0 time = 330
.meas tran vdout1_16ck65 FIND v(dout1_16) AT=330.025n

* CHECK dout1_17 Vdout1_17ck65 = 0 time = 330
.meas tran vdout1_17ck65 FIND v(dout1_17) AT=330.025n

* CHECK dout1_18 Vdout1_18ck65 = 0 time = 330
.meas tran vdout1_18ck65 FIND v(dout1_18) AT=330.025n

* CHECK dout1_19 Vdout1_19ck65 = 0 time = 330
.meas tran vdout1_19ck65 FIND v(dout1_19) AT=330.025n

* CHECK dout1_20 Vdout1_20ck65 = 0.9 time = 330
.meas tran vdout1_20ck65 FIND v(dout1_20) AT=330.025n

* CHECK dout1_21 Vdout1_21ck65 = 0.9 time = 330
.meas tran vdout1_21ck65 FIND v(dout1_21) AT=330.025n

* CHECK dout1_22 Vdout1_22ck65 = 0.9 time = 330
.meas tran vdout1_22ck65 FIND v(dout1_22) AT=330.025n

* CHECK dout1_23 Vdout1_23ck65 = 0 time = 330
.meas tran vdout1_23ck65 FIND v(dout1_23) AT=330.025n

* CHECK dout1_24 Vdout1_24ck65 = 0.9 time = 330
.meas tran vdout1_24ck65 FIND v(dout1_24) AT=330.025n

* CHECK dout1_25 Vdout1_25ck65 = 0 time = 330
.meas tran vdout1_25ck65 FIND v(dout1_25) AT=330.025n

* CHECK dout1_26 Vdout1_26ck65 = 0.9 time = 330
.meas tran vdout1_26ck65 FIND v(dout1_26) AT=330.025n

* CHECK dout1_27 Vdout1_27ck65 = 0.9 time = 330
.meas tran vdout1_27ck65 FIND v(dout1_27) AT=330.025n

* CHECK dout1_28 Vdout1_28ck65 = 0.9 time = 330
.meas tran vdout1_28ck65 FIND v(dout1_28) AT=330.025n

* CHECK dout1_29 Vdout1_29ck65 = 0 time = 330
.meas tran vdout1_29ck65 FIND v(dout1_29) AT=330.025n

* CHECK dout1_30 Vdout1_30ck65 = 0 time = 330
.meas tran vdout1_30ck65 FIND v(dout1_30) AT=330.025n

* CHECK dout1_31 Vdout1_31ck65 = 0 time = 330
.meas tran vdout1_31ck65 FIND v(dout1_31) AT=330.025n

* CHECK dout1_32 Vdout1_32ck65 = 0.9 time = 330
.meas tran vdout1_32ck65 FIND v(dout1_32) AT=330.025n

* CHECK dout1_33 Vdout1_33ck65 = 0 time = 330
.meas tran vdout1_33ck65 FIND v(dout1_33) AT=330.025n

* CHECK dout1_34 Vdout1_34ck65 = 0.9 time = 330
.meas tran vdout1_34ck65 FIND v(dout1_34) AT=330.025n

* CHECK dout1_35 Vdout1_35ck65 = 0 time = 330
.meas tran vdout1_35ck65 FIND v(dout1_35) AT=330.025n

* CHECK dout1_36 Vdout1_36ck65 = 0 time = 330
.meas tran vdout1_36ck65 FIND v(dout1_36) AT=330.025n

* CHECK dout1_37 Vdout1_37ck65 = 0.9 time = 330
.meas tran vdout1_37ck65 FIND v(dout1_37) AT=330.025n

* CHECK dout1_38 Vdout1_38ck65 = 0 time = 330
.meas tran vdout1_38ck65 FIND v(dout1_38) AT=330.025n

* CHECK dout1_39 Vdout1_39ck65 = 0.9 time = 330
.meas tran vdout1_39ck65 FIND v(dout1_39) AT=330.025n

* CHECK dout1_40 Vdout1_40ck65 = 0.9 time = 330
.meas tran vdout1_40ck65 FIND v(dout1_40) AT=330.025n

* CHECK dout1_41 Vdout1_41ck65 = 0.9 time = 330
.meas tran vdout1_41ck65 FIND v(dout1_41) AT=330.025n

* CHECK dout1_42 Vdout1_42ck65 = 0.9 time = 330
.meas tran vdout1_42ck65 FIND v(dout1_42) AT=330.025n

* CHECK dout1_43 Vdout1_43ck65 = 0.9 time = 330
.meas tran vdout1_43ck65 FIND v(dout1_43) AT=330.025n

* CHECK dout1_44 Vdout1_44ck65 = 0 time = 330
.meas tran vdout1_44ck65 FIND v(dout1_44) AT=330.025n

* CHECK dout1_45 Vdout1_45ck65 = 0.9 time = 330
.meas tran vdout1_45ck65 FIND v(dout1_45) AT=330.025n

* CHECK dout1_46 Vdout1_46ck65 = 0.9 time = 330
.meas tran vdout1_46ck65 FIND v(dout1_46) AT=330.025n

* CHECK dout1_47 Vdout1_47ck65 = 0 time = 330
.meas tran vdout1_47ck65 FIND v(dout1_47) AT=330.025n

* CHECK dout1_48 Vdout1_48ck65 = 0.9 time = 330
.meas tran vdout1_48ck65 FIND v(dout1_48) AT=330.025n

* CHECK dout1_49 Vdout1_49ck65 = 0.9 time = 330
.meas tran vdout1_49ck65 FIND v(dout1_49) AT=330.025n

* CHECK dout1_50 Vdout1_50ck65 = 0.9 time = 330
.meas tran vdout1_50ck65 FIND v(dout1_50) AT=330.025n

* CHECK dout1_51 Vdout1_51ck65 = 0.9 time = 330
.meas tran vdout1_51ck65 FIND v(dout1_51) AT=330.025n

* CHECK dout1_52 Vdout1_52ck65 = 0.9 time = 330
.meas tran vdout1_52ck65 FIND v(dout1_52) AT=330.025n

* CHECK dout1_53 Vdout1_53ck65 = 0.9 time = 330
.meas tran vdout1_53ck65 FIND v(dout1_53) AT=330.025n

* CHECK dout1_54 Vdout1_54ck65 = 0 time = 330
.meas tran vdout1_54ck65 FIND v(dout1_54) AT=330.025n

* CHECK dout1_55 Vdout1_55ck65 = 0.9 time = 330
.meas tran vdout1_55ck65 FIND v(dout1_55) AT=330.025n

* CHECK dout1_56 Vdout1_56ck65 = 0 time = 330
.meas tran vdout1_56ck65 FIND v(dout1_56) AT=330.025n

* CHECK dout1_57 Vdout1_57ck65 = 0 time = 330
.meas tran vdout1_57ck65 FIND v(dout1_57) AT=330.025n

* CHECK dout1_58 Vdout1_58ck65 = 0.9 time = 330
.meas tran vdout1_58ck65 FIND v(dout1_58) AT=330.025n

* CHECK dout1_59 Vdout1_59ck65 = 0.9 time = 330
.meas tran vdout1_59ck65 FIND v(dout1_59) AT=330.025n

* CHECK dout1_60 Vdout1_60ck65 = 0 time = 330
.meas tran vdout1_60ck65 FIND v(dout1_60) AT=330.025n

* CHECK dout1_61 Vdout1_61ck65 = 0 time = 330
.meas tran vdout1_61ck65 FIND v(dout1_61) AT=330.025n

* CHECK dout1_62 Vdout1_62ck65 = 0.9 time = 330
.meas tran vdout1_62ck65 FIND v(dout1_62) AT=330.025n

* CHECK dout1_63 Vdout1_63ck65 = 0 time = 330
.meas tran vdout1_63ck65 FIND v(dout1_63) AT=330.025n

* CHECK dout1_64 Vdout1_64ck65 = 0 time = 330
.meas tran vdout1_64ck65 FIND v(dout1_64) AT=330.025n

* CHECK dout1_65 Vdout1_65ck65 = 0.9 time = 330
.meas tran vdout1_65ck65 FIND v(dout1_65) AT=330.025n

* CHECK dout1_66 Vdout1_66ck65 = 0 time = 330
.meas tran vdout1_66ck65 FIND v(dout1_66) AT=330.025n

* CHECK dout1_67 Vdout1_67ck65 = 0 time = 330
.meas tran vdout1_67ck65 FIND v(dout1_67) AT=330.025n

* CHECK dout1_68 Vdout1_68ck65 = 0.9 time = 330
.meas tran vdout1_68ck65 FIND v(dout1_68) AT=330.025n

* CHECK dout1_69 Vdout1_69ck65 = 0 time = 330
.meas tran vdout1_69ck65 FIND v(dout1_69) AT=330.025n

* CHECK dout1_70 Vdout1_70ck65 = 0 time = 330
.meas tran vdout1_70ck65 FIND v(dout1_70) AT=330.025n

* CHECK dout1_71 Vdout1_71ck65 = 0 time = 330
.meas tran vdout1_71ck65 FIND v(dout1_71) AT=330.025n

* CHECK dout1_72 Vdout1_72ck65 = 0.9 time = 330
.meas tran vdout1_72ck65 FIND v(dout1_72) AT=330.025n

* CHECK dout1_73 Vdout1_73ck65 = 0 time = 330
.meas tran vdout1_73ck65 FIND v(dout1_73) AT=330.025n

* CHECK dout1_74 Vdout1_74ck65 = 0.9 time = 330
.meas tran vdout1_74ck65 FIND v(dout1_74) AT=330.025n

* CHECK dout1_75 Vdout1_75ck65 = 0 time = 330
.meas tran vdout1_75ck65 FIND v(dout1_75) AT=330.025n

* CHECK dout1_76 Vdout1_76ck65 = 0.9 time = 330
.meas tran vdout1_76ck65 FIND v(dout1_76) AT=330.025n

* CHECK dout1_77 Vdout1_77ck65 = 0 time = 330
.meas tran vdout1_77ck65 FIND v(dout1_77) AT=330.025n

* CHECK dout1_78 Vdout1_78ck65 = 0 time = 330
.meas tran vdout1_78ck65 FIND v(dout1_78) AT=330.025n

* CHECK dout1_79 Vdout1_79ck65 = 0 time = 330
.meas tran vdout1_79ck65 FIND v(dout1_79) AT=330.025n

* CHECK dout1_80 Vdout1_80ck65 = 0 time = 330
.meas tran vdout1_80ck65 FIND v(dout1_80) AT=330.025n

* CHECK dout1_81 Vdout1_81ck65 = 0 time = 330
.meas tran vdout1_81ck65 FIND v(dout1_81) AT=330.025n

* CHECK dout1_82 Vdout1_82ck65 = 0.9 time = 330
.meas tran vdout1_82ck65 FIND v(dout1_82) AT=330.025n

* CHECK dout1_83 Vdout1_83ck65 = 0.9 time = 330
.meas tran vdout1_83ck65 FIND v(dout1_83) AT=330.025n

* CHECK dout1_84 Vdout1_84ck65 = 0.9 time = 330
.meas tran vdout1_84ck65 FIND v(dout1_84) AT=330.025n

* CHECK dout1_85 Vdout1_85ck65 = 0.9 time = 330
.meas tran vdout1_85ck65 FIND v(dout1_85) AT=330.025n

* CHECK dout1_86 Vdout1_86ck65 = 0.9 time = 330
.meas tran vdout1_86ck65 FIND v(dout1_86) AT=330.025n

* CHECK dout1_87 Vdout1_87ck65 = 0.9 time = 330
.meas tran vdout1_87ck65 FIND v(dout1_87) AT=330.025n

* CHECK dout1_88 Vdout1_88ck65 = 0 time = 330
.meas tran vdout1_88ck65 FIND v(dout1_88) AT=330.025n

* CHECK dout1_89 Vdout1_89ck65 = 0 time = 330
.meas tran vdout1_89ck65 FIND v(dout1_89) AT=330.025n

* CHECK dout1_90 Vdout1_90ck65 = 0.9 time = 330
.meas tran vdout1_90ck65 FIND v(dout1_90) AT=330.025n

* CHECK dout1_91 Vdout1_91ck65 = 0.9 time = 330
.meas tran vdout1_91ck65 FIND v(dout1_91) AT=330.025n

* CHECK dout1_92 Vdout1_92ck65 = 0 time = 330
.meas tran vdout1_92ck65 FIND v(dout1_92) AT=330.025n

* CHECK dout1_93 Vdout1_93ck65 = 0.9 time = 330
.meas tran vdout1_93ck65 FIND v(dout1_93) AT=330.025n

* CHECK dout1_94 Vdout1_94ck65 = 0.9 time = 330
.meas tran vdout1_94ck65 FIND v(dout1_94) AT=330.025n

* CHECK dout1_95 Vdout1_95ck65 = 0 time = 330
.meas tran vdout1_95ck65 FIND v(dout1_95) AT=330.025n

* CHECK dout1_96 Vdout1_96ck65 = 0 time = 330
.meas tran vdout1_96ck65 FIND v(dout1_96) AT=330.025n

* CHECK dout1_97 Vdout1_97ck65 = 0 time = 330
.meas tran vdout1_97ck65 FIND v(dout1_97) AT=330.025n

* CHECK dout1_98 Vdout1_98ck65 = 0 time = 330
.meas tran vdout1_98ck65 FIND v(dout1_98) AT=330.025n

* CHECK dout1_99 Vdout1_99ck65 = 0.9 time = 330
.meas tran vdout1_99ck65 FIND v(dout1_99) AT=330.025n

* CHECK dout1_100 Vdout1_100ck65 = 0.9 time = 330
.meas tran vdout1_100ck65 FIND v(dout1_100) AT=330.025n

* CHECK dout1_101 Vdout1_101ck65 = 0 time = 330
.meas tran vdout1_101ck65 FIND v(dout1_101) AT=330.025n

* CHECK dout1_102 Vdout1_102ck65 = 0 time = 330
.meas tran vdout1_102ck65 FIND v(dout1_102) AT=330.025n

* CHECK dout1_103 Vdout1_103ck65 = 0.9 time = 330
.meas tran vdout1_103ck65 FIND v(dout1_103) AT=330.025n

* CHECK dout1_104 Vdout1_104ck65 = 0 time = 330
.meas tran vdout1_104ck65 FIND v(dout1_104) AT=330.025n

* CHECK dout1_105 Vdout1_105ck65 = 0 time = 330
.meas tran vdout1_105ck65 FIND v(dout1_105) AT=330.025n

* CHECK dout1_106 Vdout1_106ck65 = 0.9 time = 330
.meas tran vdout1_106ck65 FIND v(dout1_106) AT=330.025n

* CHECK dout1_107 Vdout1_107ck65 = 0.9 time = 330
.meas tran vdout1_107ck65 FIND v(dout1_107) AT=330.025n

* CHECK dout1_108 Vdout1_108ck65 = 0 time = 330
.meas tran vdout1_108ck65 FIND v(dout1_108) AT=330.025n

* CHECK dout1_109 Vdout1_109ck65 = 0.9 time = 330
.meas tran vdout1_109ck65 FIND v(dout1_109) AT=330.025n

* CHECK dout1_110 Vdout1_110ck65 = 0.9 time = 330
.meas tran vdout1_110ck65 FIND v(dout1_110) AT=330.025n

* CHECK dout1_111 Vdout1_111ck65 = 0.9 time = 330
.meas tran vdout1_111ck65 FIND v(dout1_111) AT=330.025n

* CHECK dout1_112 Vdout1_112ck65 = 0.9 time = 330
.meas tran vdout1_112ck65 FIND v(dout1_112) AT=330.025n

* CHECK dout1_113 Vdout1_113ck65 = 0.9 time = 330
.meas tran vdout1_113ck65 FIND v(dout1_113) AT=330.025n

* CHECK dout1_114 Vdout1_114ck65 = 0 time = 330
.meas tran vdout1_114ck65 FIND v(dout1_114) AT=330.025n

* CHECK dout1_115 Vdout1_115ck65 = 0 time = 330
.meas tran vdout1_115ck65 FIND v(dout1_115) AT=330.025n

* CHECK dout1_116 Vdout1_116ck65 = 0.9 time = 330
.meas tran vdout1_116ck65 FIND v(dout1_116) AT=330.025n

* CHECK dout1_117 Vdout1_117ck65 = 0 time = 330
.meas tran vdout1_117ck65 FIND v(dout1_117) AT=330.025n

* CHECK dout1_118 Vdout1_118ck65 = 0.9 time = 330
.meas tran vdout1_118ck65 FIND v(dout1_118) AT=330.025n

* CHECK dout1_119 Vdout1_119ck65 = 0.9 time = 330
.meas tran vdout1_119ck65 FIND v(dout1_119) AT=330.025n

* CHECK dout1_0 Vdout1_0ck66 = 0 time = 335
.meas tran vdout1_0ck66 FIND v(dout1_0) AT=335.025n

* CHECK dout1_1 Vdout1_1ck66 = 0 time = 335
.meas tran vdout1_1ck66 FIND v(dout1_1) AT=335.025n

* CHECK dout1_2 Vdout1_2ck66 = 0.9 time = 335
.meas tran vdout1_2ck66 FIND v(dout1_2) AT=335.025n

* CHECK dout1_3 Vdout1_3ck66 = 0 time = 335
.meas tran vdout1_3ck66 FIND v(dout1_3) AT=335.025n

* CHECK dout1_4 Vdout1_4ck66 = 0 time = 335
.meas tran vdout1_4ck66 FIND v(dout1_4) AT=335.025n

* CHECK dout1_5 Vdout1_5ck66 = 0.9 time = 335
.meas tran vdout1_5ck66 FIND v(dout1_5) AT=335.025n

* CHECK dout1_6 Vdout1_6ck66 = 0 time = 335
.meas tran vdout1_6ck66 FIND v(dout1_6) AT=335.025n

* CHECK dout1_7 Vdout1_7ck66 = 0.9 time = 335
.meas tran vdout1_7ck66 FIND v(dout1_7) AT=335.025n

* CHECK dout1_8 Vdout1_8ck66 = 0.9 time = 335
.meas tran vdout1_8ck66 FIND v(dout1_8) AT=335.025n

* CHECK dout1_9 Vdout1_9ck66 = 0 time = 335
.meas tran vdout1_9ck66 FIND v(dout1_9) AT=335.025n

* CHECK dout1_10 Vdout1_10ck66 = 0.9 time = 335
.meas tran vdout1_10ck66 FIND v(dout1_10) AT=335.025n

* CHECK dout1_11 Vdout1_11ck66 = 0 time = 335
.meas tran vdout1_11ck66 FIND v(dout1_11) AT=335.025n

* CHECK dout1_12 Vdout1_12ck66 = 0 time = 335
.meas tran vdout1_12ck66 FIND v(dout1_12) AT=335.025n

* CHECK dout1_13 Vdout1_13ck66 = 0.9 time = 335
.meas tran vdout1_13ck66 FIND v(dout1_13) AT=335.025n

* CHECK dout1_14 Vdout1_14ck66 = 0.9 time = 335
.meas tran vdout1_14ck66 FIND v(dout1_14) AT=335.025n

* CHECK dout1_15 Vdout1_15ck66 = 0.9 time = 335
.meas tran vdout1_15ck66 FIND v(dout1_15) AT=335.025n

* CHECK dout1_16 Vdout1_16ck66 = 0 time = 335
.meas tran vdout1_16ck66 FIND v(dout1_16) AT=335.025n

* CHECK dout1_17 Vdout1_17ck66 = 0 time = 335
.meas tran vdout1_17ck66 FIND v(dout1_17) AT=335.025n

* CHECK dout1_18 Vdout1_18ck66 = 0 time = 335
.meas tran vdout1_18ck66 FIND v(dout1_18) AT=335.025n

* CHECK dout1_19 Vdout1_19ck66 = 0.9 time = 335
.meas tran vdout1_19ck66 FIND v(dout1_19) AT=335.025n

* CHECK dout1_20 Vdout1_20ck66 = 0.9 time = 335
.meas tran vdout1_20ck66 FIND v(dout1_20) AT=335.025n

* CHECK dout1_21 Vdout1_21ck66 = 0.9 time = 335
.meas tran vdout1_21ck66 FIND v(dout1_21) AT=335.025n

* CHECK dout1_22 Vdout1_22ck66 = 0 time = 335
.meas tran vdout1_22ck66 FIND v(dout1_22) AT=335.025n

* CHECK dout1_23 Vdout1_23ck66 = 0.9 time = 335
.meas tran vdout1_23ck66 FIND v(dout1_23) AT=335.025n

* CHECK dout1_24 Vdout1_24ck66 = 0 time = 335
.meas tran vdout1_24ck66 FIND v(dout1_24) AT=335.025n

* CHECK dout1_25 Vdout1_25ck66 = 0 time = 335
.meas tran vdout1_25ck66 FIND v(dout1_25) AT=335.025n

* CHECK dout1_26 Vdout1_26ck66 = 0 time = 335
.meas tran vdout1_26ck66 FIND v(dout1_26) AT=335.025n

* CHECK dout1_27 Vdout1_27ck66 = 0 time = 335
.meas tran vdout1_27ck66 FIND v(dout1_27) AT=335.025n

* CHECK dout1_28 Vdout1_28ck66 = 0.9 time = 335
.meas tran vdout1_28ck66 FIND v(dout1_28) AT=335.025n

* CHECK dout1_29 Vdout1_29ck66 = 0.9 time = 335
.meas tran vdout1_29ck66 FIND v(dout1_29) AT=335.025n

* CHECK dout1_30 Vdout1_30ck66 = 0 time = 335
.meas tran vdout1_30ck66 FIND v(dout1_30) AT=335.025n

* CHECK dout1_31 Vdout1_31ck66 = 0 time = 335
.meas tran vdout1_31ck66 FIND v(dout1_31) AT=335.025n

* CHECK dout1_32 Vdout1_32ck66 = 0.9 time = 335
.meas tran vdout1_32ck66 FIND v(dout1_32) AT=335.025n

* CHECK dout1_33 Vdout1_33ck66 = 0.9 time = 335
.meas tran vdout1_33ck66 FIND v(dout1_33) AT=335.025n

* CHECK dout1_34 Vdout1_34ck66 = 0 time = 335
.meas tran vdout1_34ck66 FIND v(dout1_34) AT=335.025n

* CHECK dout1_35 Vdout1_35ck66 = 0 time = 335
.meas tran vdout1_35ck66 FIND v(dout1_35) AT=335.025n

* CHECK dout1_36 Vdout1_36ck66 = 0.9 time = 335
.meas tran vdout1_36ck66 FIND v(dout1_36) AT=335.025n

* CHECK dout1_37 Vdout1_37ck66 = 0 time = 335
.meas tran vdout1_37ck66 FIND v(dout1_37) AT=335.025n

* CHECK dout1_38 Vdout1_38ck66 = 0.9 time = 335
.meas tran vdout1_38ck66 FIND v(dout1_38) AT=335.025n

* CHECK dout1_39 Vdout1_39ck66 = 0 time = 335
.meas tran vdout1_39ck66 FIND v(dout1_39) AT=335.025n

* CHECK dout1_40 Vdout1_40ck66 = 0 time = 335
.meas tran vdout1_40ck66 FIND v(dout1_40) AT=335.025n

* CHECK dout1_41 Vdout1_41ck66 = 0 time = 335
.meas tran vdout1_41ck66 FIND v(dout1_41) AT=335.025n

* CHECK dout1_42 Vdout1_42ck66 = 0.9 time = 335
.meas tran vdout1_42ck66 FIND v(dout1_42) AT=335.025n

* CHECK dout1_43 Vdout1_43ck66 = 0 time = 335
.meas tran vdout1_43ck66 FIND v(dout1_43) AT=335.025n

* CHECK dout1_44 Vdout1_44ck66 = 0.9 time = 335
.meas tran vdout1_44ck66 FIND v(dout1_44) AT=335.025n

* CHECK dout1_45 Vdout1_45ck66 = 0 time = 335
.meas tran vdout1_45ck66 FIND v(dout1_45) AT=335.025n

* CHECK dout1_46 Vdout1_46ck66 = 0.9 time = 335
.meas tran vdout1_46ck66 FIND v(dout1_46) AT=335.025n

* CHECK dout1_47 Vdout1_47ck66 = 0 time = 335
.meas tran vdout1_47ck66 FIND v(dout1_47) AT=335.025n

* CHECK dout1_48 Vdout1_48ck66 = 0.9 time = 335
.meas tran vdout1_48ck66 FIND v(dout1_48) AT=335.025n

* CHECK dout1_49 Vdout1_49ck66 = 0.9 time = 335
.meas tran vdout1_49ck66 FIND v(dout1_49) AT=335.025n

* CHECK dout1_50 Vdout1_50ck66 = 0 time = 335
.meas tran vdout1_50ck66 FIND v(dout1_50) AT=335.025n

* CHECK dout1_51 Vdout1_51ck66 = 0.9 time = 335
.meas tran vdout1_51ck66 FIND v(dout1_51) AT=335.025n

* CHECK dout1_52 Vdout1_52ck66 = 0.9 time = 335
.meas tran vdout1_52ck66 FIND v(dout1_52) AT=335.025n

* CHECK dout1_53 Vdout1_53ck66 = 0 time = 335
.meas tran vdout1_53ck66 FIND v(dout1_53) AT=335.025n

* CHECK dout1_54 Vdout1_54ck66 = 0 time = 335
.meas tran vdout1_54ck66 FIND v(dout1_54) AT=335.025n

* CHECK dout1_55 Vdout1_55ck66 = 0 time = 335
.meas tran vdout1_55ck66 FIND v(dout1_55) AT=335.025n

* CHECK dout1_56 Vdout1_56ck66 = 0.9 time = 335
.meas tran vdout1_56ck66 FIND v(dout1_56) AT=335.025n

* CHECK dout1_57 Vdout1_57ck66 = 0 time = 335
.meas tran vdout1_57ck66 FIND v(dout1_57) AT=335.025n

* CHECK dout1_58 Vdout1_58ck66 = 0.9 time = 335
.meas tran vdout1_58ck66 FIND v(dout1_58) AT=335.025n

* CHECK dout1_59 Vdout1_59ck66 = 0.9 time = 335
.meas tran vdout1_59ck66 FIND v(dout1_59) AT=335.025n

* CHECK dout1_60 Vdout1_60ck66 = 0.9 time = 335
.meas tran vdout1_60ck66 FIND v(dout1_60) AT=335.025n

* CHECK dout1_61 Vdout1_61ck66 = 0 time = 335
.meas tran vdout1_61ck66 FIND v(dout1_61) AT=335.025n

* CHECK dout1_62 Vdout1_62ck66 = 0 time = 335
.meas tran vdout1_62ck66 FIND v(dout1_62) AT=335.025n

* CHECK dout1_63 Vdout1_63ck66 = 0 time = 335
.meas tran vdout1_63ck66 FIND v(dout1_63) AT=335.025n

* CHECK dout1_64 Vdout1_64ck66 = 0 time = 335
.meas tran vdout1_64ck66 FIND v(dout1_64) AT=335.025n

* CHECK dout1_65 Vdout1_65ck66 = 0.9 time = 335
.meas tran vdout1_65ck66 FIND v(dout1_65) AT=335.025n

* CHECK dout1_66 Vdout1_66ck66 = 0 time = 335
.meas tran vdout1_66ck66 FIND v(dout1_66) AT=335.025n

* CHECK dout1_67 Vdout1_67ck66 = 0.9 time = 335
.meas tran vdout1_67ck66 FIND v(dout1_67) AT=335.025n

* CHECK dout1_68 Vdout1_68ck66 = 0 time = 335
.meas tran vdout1_68ck66 FIND v(dout1_68) AT=335.025n

* CHECK dout1_69 Vdout1_69ck66 = 0.9 time = 335
.meas tran vdout1_69ck66 FIND v(dout1_69) AT=335.025n

* CHECK dout1_70 Vdout1_70ck66 = 0 time = 335
.meas tran vdout1_70ck66 FIND v(dout1_70) AT=335.025n

* CHECK dout1_71 Vdout1_71ck66 = 0.9 time = 335
.meas tran vdout1_71ck66 FIND v(dout1_71) AT=335.025n

* CHECK dout1_72 Vdout1_72ck66 = 0 time = 335
.meas tran vdout1_72ck66 FIND v(dout1_72) AT=335.025n

* CHECK dout1_73 Vdout1_73ck66 = 0 time = 335
.meas tran vdout1_73ck66 FIND v(dout1_73) AT=335.025n

* CHECK dout1_74 Vdout1_74ck66 = 0 time = 335
.meas tran vdout1_74ck66 FIND v(dout1_74) AT=335.025n

* CHECK dout1_75 Vdout1_75ck66 = 0 time = 335
.meas tran vdout1_75ck66 FIND v(dout1_75) AT=335.025n

* CHECK dout1_76 Vdout1_76ck66 = 0 time = 335
.meas tran vdout1_76ck66 FIND v(dout1_76) AT=335.025n

* CHECK dout1_77 Vdout1_77ck66 = 0 time = 335
.meas tran vdout1_77ck66 FIND v(dout1_77) AT=335.025n

* CHECK dout1_78 Vdout1_78ck66 = 0.9 time = 335
.meas tran vdout1_78ck66 FIND v(dout1_78) AT=335.025n

* CHECK dout1_79 Vdout1_79ck66 = 0.9 time = 335
.meas tran vdout1_79ck66 FIND v(dout1_79) AT=335.025n

* CHECK dout1_80 Vdout1_80ck66 = 0.9 time = 335
.meas tran vdout1_80ck66 FIND v(dout1_80) AT=335.025n

* CHECK dout1_81 Vdout1_81ck66 = 0.9 time = 335
.meas tran vdout1_81ck66 FIND v(dout1_81) AT=335.025n

* CHECK dout1_82 Vdout1_82ck66 = 0.9 time = 335
.meas tran vdout1_82ck66 FIND v(dout1_82) AT=335.025n

* CHECK dout1_83 Vdout1_83ck66 = 0.9 time = 335
.meas tran vdout1_83ck66 FIND v(dout1_83) AT=335.025n

* CHECK dout1_84 Vdout1_84ck66 = 0.9 time = 335
.meas tran vdout1_84ck66 FIND v(dout1_84) AT=335.025n

* CHECK dout1_85 Vdout1_85ck66 = 0 time = 335
.meas tran vdout1_85ck66 FIND v(dout1_85) AT=335.025n

* CHECK dout1_86 Vdout1_86ck66 = 0.9 time = 335
.meas tran vdout1_86ck66 FIND v(dout1_86) AT=335.025n

* CHECK dout1_87 Vdout1_87ck66 = 0 time = 335
.meas tran vdout1_87ck66 FIND v(dout1_87) AT=335.025n

* CHECK dout1_88 Vdout1_88ck66 = 0 time = 335
.meas tran vdout1_88ck66 FIND v(dout1_88) AT=335.025n

* CHECK dout1_89 Vdout1_89ck66 = 0 time = 335
.meas tran vdout1_89ck66 FIND v(dout1_89) AT=335.025n

* CHECK dout1_90 Vdout1_90ck66 = 0 time = 335
.meas tran vdout1_90ck66 FIND v(dout1_90) AT=335.025n

* CHECK dout1_91 Vdout1_91ck66 = 0 time = 335
.meas tran vdout1_91ck66 FIND v(dout1_91) AT=335.025n

* CHECK dout1_92 Vdout1_92ck66 = 0 time = 335
.meas tran vdout1_92ck66 FIND v(dout1_92) AT=335.025n

* CHECK dout1_93 Vdout1_93ck66 = 0.9 time = 335
.meas tran vdout1_93ck66 FIND v(dout1_93) AT=335.025n

* CHECK dout1_94 Vdout1_94ck66 = 0 time = 335
.meas tran vdout1_94ck66 FIND v(dout1_94) AT=335.025n

* CHECK dout1_95 Vdout1_95ck66 = 0 time = 335
.meas tran vdout1_95ck66 FIND v(dout1_95) AT=335.025n

* CHECK dout1_96 Vdout1_96ck66 = 0.9 time = 335
.meas tran vdout1_96ck66 FIND v(dout1_96) AT=335.025n

* CHECK dout1_97 Vdout1_97ck66 = 0 time = 335
.meas tran vdout1_97ck66 FIND v(dout1_97) AT=335.025n

* CHECK dout1_98 Vdout1_98ck66 = 0 time = 335
.meas tran vdout1_98ck66 FIND v(dout1_98) AT=335.025n

* CHECK dout1_99 Vdout1_99ck66 = 0 time = 335
.meas tran vdout1_99ck66 FIND v(dout1_99) AT=335.025n

* CHECK dout1_100 Vdout1_100ck66 = 0 time = 335
.meas tran vdout1_100ck66 FIND v(dout1_100) AT=335.025n

* CHECK dout1_101 Vdout1_101ck66 = 0 time = 335
.meas tran vdout1_101ck66 FIND v(dout1_101) AT=335.025n

* CHECK dout1_102 Vdout1_102ck66 = 0 time = 335
.meas tran vdout1_102ck66 FIND v(dout1_102) AT=335.025n

* CHECK dout1_103 Vdout1_103ck66 = 0.9 time = 335
.meas tran vdout1_103ck66 FIND v(dout1_103) AT=335.025n

* CHECK dout1_104 Vdout1_104ck66 = 0.9 time = 335
.meas tran vdout1_104ck66 FIND v(dout1_104) AT=335.025n

* CHECK dout1_105 Vdout1_105ck66 = 0 time = 335
.meas tran vdout1_105ck66 FIND v(dout1_105) AT=335.025n

* CHECK dout1_106 Vdout1_106ck66 = 0.9 time = 335
.meas tran vdout1_106ck66 FIND v(dout1_106) AT=335.025n

* CHECK dout1_107 Vdout1_107ck66 = 0.9 time = 335
.meas tran vdout1_107ck66 FIND v(dout1_107) AT=335.025n

* CHECK dout1_108 Vdout1_108ck66 = 0.9 time = 335
.meas tran vdout1_108ck66 FIND v(dout1_108) AT=335.025n

* CHECK dout1_109 Vdout1_109ck66 = 0.9 time = 335
.meas tran vdout1_109ck66 FIND v(dout1_109) AT=335.025n

* CHECK dout1_110 Vdout1_110ck66 = 0.9 time = 335
.meas tran vdout1_110ck66 FIND v(dout1_110) AT=335.025n

* CHECK dout1_111 Vdout1_111ck66 = 0.9 time = 335
.meas tran vdout1_111ck66 FIND v(dout1_111) AT=335.025n

* CHECK dout1_112 Vdout1_112ck66 = 0.9 time = 335
.meas tran vdout1_112ck66 FIND v(dout1_112) AT=335.025n

* CHECK dout1_113 Vdout1_113ck66 = 0 time = 335
.meas tran vdout1_113ck66 FIND v(dout1_113) AT=335.025n

* CHECK dout1_114 Vdout1_114ck66 = 0 time = 335
.meas tran vdout1_114ck66 FIND v(dout1_114) AT=335.025n

* CHECK dout1_115 Vdout1_115ck66 = 0 time = 335
.meas tran vdout1_115ck66 FIND v(dout1_115) AT=335.025n

* CHECK dout1_116 Vdout1_116ck66 = 0.9 time = 335
.meas tran vdout1_116ck66 FIND v(dout1_116) AT=335.025n

* CHECK dout1_117 Vdout1_117ck66 = 0.9 time = 335
.meas tran vdout1_117ck66 FIND v(dout1_117) AT=335.025n

* CHECK dout1_118 Vdout1_118ck66 = 0.9 time = 335
.meas tran vdout1_118ck66 FIND v(dout1_118) AT=335.025n

* CHECK dout1_119 Vdout1_119ck66 = 0.9 time = 335
.meas tran vdout1_119ck66 FIND v(dout1_119) AT=335.025n

* CHECK dout1_0 Vdout1_0ck69 = 0.9 time = 350
.meas tran vdout1_0ck69 FIND v(dout1_0) AT=350.025n

* CHECK dout1_1 Vdout1_1ck69 = 0 time = 350
.meas tran vdout1_1ck69 FIND v(dout1_1) AT=350.025n

* CHECK dout1_2 Vdout1_2ck69 = 0 time = 350
.meas tran vdout1_2ck69 FIND v(dout1_2) AT=350.025n

* CHECK dout1_3 Vdout1_3ck69 = 0 time = 350
.meas tran vdout1_3ck69 FIND v(dout1_3) AT=350.025n

* CHECK dout1_4 Vdout1_4ck69 = 0 time = 350
.meas tran vdout1_4ck69 FIND v(dout1_4) AT=350.025n

* CHECK dout1_5 Vdout1_5ck69 = 0 time = 350
.meas tran vdout1_5ck69 FIND v(dout1_5) AT=350.025n

* CHECK dout1_6 Vdout1_6ck69 = 0 time = 350
.meas tran vdout1_6ck69 FIND v(dout1_6) AT=350.025n

* CHECK dout1_7 Vdout1_7ck69 = 0.9 time = 350
.meas tran vdout1_7ck69 FIND v(dout1_7) AT=350.025n

* CHECK dout1_8 Vdout1_8ck69 = 0 time = 350
.meas tran vdout1_8ck69 FIND v(dout1_8) AT=350.025n

* CHECK dout1_9 Vdout1_9ck69 = 0 time = 350
.meas tran vdout1_9ck69 FIND v(dout1_9) AT=350.025n

* CHECK dout1_10 Vdout1_10ck69 = 0 time = 350
.meas tran vdout1_10ck69 FIND v(dout1_10) AT=350.025n

* CHECK dout1_11 Vdout1_11ck69 = 0 time = 350
.meas tran vdout1_11ck69 FIND v(dout1_11) AT=350.025n

* CHECK dout1_12 Vdout1_12ck69 = 0 time = 350
.meas tran vdout1_12ck69 FIND v(dout1_12) AT=350.025n

* CHECK dout1_13 Vdout1_13ck69 = 0.9 time = 350
.meas tran vdout1_13ck69 FIND v(dout1_13) AT=350.025n

* CHECK dout1_14 Vdout1_14ck69 = 0 time = 350
.meas tran vdout1_14ck69 FIND v(dout1_14) AT=350.025n

* CHECK dout1_15 Vdout1_15ck69 = 0.9 time = 350
.meas tran vdout1_15ck69 FIND v(dout1_15) AT=350.025n

* CHECK dout1_16 Vdout1_16ck69 = 0.9 time = 350
.meas tran vdout1_16ck69 FIND v(dout1_16) AT=350.025n

* CHECK dout1_17 Vdout1_17ck69 = 0 time = 350
.meas tran vdout1_17ck69 FIND v(dout1_17) AT=350.025n

* CHECK dout1_18 Vdout1_18ck69 = 0.9 time = 350
.meas tran vdout1_18ck69 FIND v(dout1_18) AT=350.025n

* CHECK dout1_19 Vdout1_19ck69 = 0 time = 350
.meas tran vdout1_19ck69 FIND v(dout1_19) AT=350.025n

* CHECK dout1_20 Vdout1_20ck69 = 0.9 time = 350
.meas tran vdout1_20ck69 FIND v(dout1_20) AT=350.025n

* CHECK dout1_21 Vdout1_21ck69 = 0 time = 350
.meas tran vdout1_21ck69 FIND v(dout1_21) AT=350.025n

* CHECK dout1_22 Vdout1_22ck69 = 0.9 time = 350
.meas tran vdout1_22ck69 FIND v(dout1_22) AT=350.025n

* CHECK dout1_23 Vdout1_23ck69 = 0.9 time = 350
.meas tran vdout1_23ck69 FIND v(dout1_23) AT=350.025n

* CHECK dout1_24 Vdout1_24ck69 = 0.9 time = 350
.meas tran vdout1_24ck69 FIND v(dout1_24) AT=350.025n

* CHECK dout1_25 Vdout1_25ck69 = 0.9 time = 350
.meas tran vdout1_25ck69 FIND v(dout1_25) AT=350.025n

* CHECK dout1_26 Vdout1_26ck69 = 0.9 time = 350
.meas tran vdout1_26ck69 FIND v(dout1_26) AT=350.025n

* CHECK dout1_27 Vdout1_27ck69 = 0.9 time = 350
.meas tran vdout1_27ck69 FIND v(dout1_27) AT=350.025n

* CHECK dout1_28 Vdout1_28ck69 = 0 time = 350
.meas tran vdout1_28ck69 FIND v(dout1_28) AT=350.025n

* CHECK dout1_29 Vdout1_29ck69 = 0 time = 350
.meas tran vdout1_29ck69 FIND v(dout1_29) AT=350.025n

* CHECK dout1_30 Vdout1_30ck69 = 0.9 time = 350
.meas tran vdout1_30ck69 FIND v(dout1_30) AT=350.025n

* CHECK dout1_31 Vdout1_31ck69 = 0.9 time = 350
.meas tran vdout1_31ck69 FIND v(dout1_31) AT=350.025n

* CHECK dout1_32 Vdout1_32ck69 = 0.9 time = 350
.meas tran vdout1_32ck69 FIND v(dout1_32) AT=350.025n

* CHECK dout1_33 Vdout1_33ck69 = 0 time = 350
.meas tran vdout1_33ck69 FIND v(dout1_33) AT=350.025n

* CHECK dout1_34 Vdout1_34ck69 = 0 time = 350
.meas tran vdout1_34ck69 FIND v(dout1_34) AT=350.025n

* CHECK dout1_35 Vdout1_35ck69 = 0 time = 350
.meas tran vdout1_35ck69 FIND v(dout1_35) AT=350.025n

* CHECK dout1_36 Vdout1_36ck69 = 0 time = 350
.meas tran vdout1_36ck69 FIND v(dout1_36) AT=350.025n

* CHECK dout1_37 Vdout1_37ck69 = 0 time = 350
.meas tran vdout1_37ck69 FIND v(dout1_37) AT=350.025n

* CHECK dout1_38 Vdout1_38ck69 = 0 time = 350
.meas tran vdout1_38ck69 FIND v(dout1_38) AT=350.025n

* CHECK dout1_39 Vdout1_39ck69 = 0.9 time = 350
.meas tran vdout1_39ck69 FIND v(dout1_39) AT=350.025n

* CHECK dout1_40 Vdout1_40ck69 = 0 time = 350
.meas tran vdout1_40ck69 FIND v(dout1_40) AT=350.025n

* CHECK dout1_41 Vdout1_41ck69 = 0 time = 350
.meas tran vdout1_41ck69 FIND v(dout1_41) AT=350.025n

* CHECK dout1_42 Vdout1_42ck69 = 0.9 time = 350
.meas tran vdout1_42ck69 FIND v(dout1_42) AT=350.025n

* CHECK dout1_43 Vdout1_43ck69 = 0.9 time = 350
.meas tran vdout1_43ck69 FIND v(dout1_43) AT=350.025n

* CHECK dout1_44 Vdout1_44ck69 = 0 time = 350
.meas tran vdout1_44ck69 FIND v(dout1_44) AT=350.025n

* CHECK dout1_45 Vdout1_45ck69 = 0.9 time = 350
.meas tran vdout1_45ck69 FIND v(dout1_45) AT=350.025n

* CHECK dout1_46 Vdout1_46ck69 = 0 time = 350
.meas tran vdout1_46ck69 FIND v(dout1_46) AT=350.025n

* CHECK dout1_47 Vdout1_47ck69 = 0 time = 350
.meas tran vdout1_47ck69 FIND v(dout1_47) AT=350.025n

* CHECK dout1_48 Vdout1_48ck69 = 0 time = 350
.meas tran vdout1_48ck69 FIND v(dout1_48) AT=350.025n

* CHECK dout1_49 Vdout1_49ck69 = 0.9 time = 350
.meas tran vdout1_49ck69 FIND v(dout1_49) AT=350.025n

* CHECK dout1_50 Vdout1_50ck69 = 0 time = 350
.meas tran vdout1_50ck69 FIND v(dout1_50) AT=350.025n

* CHECK dout1_51 Vdout1_51ck69 = 0.9 time = 350
.meas tran vdout1_51ck69 FIND v(dout1_51) AT=350.025n

* CHECK dout1_52 Vdout1_52ck69 = 0 time = 350
.meas tran vdout1_52ck69 FIND v(dout1_52) AT=350.025n

* CHECK dout1_53 Vdout1_53ck69 = 0.9 time = 350
.meas tran vdout1_53ck69 FIND v(dout1_53) AT=350.025n

* CHECK dout1_54 Vdout1_54ck69 = 0.9 time = 350
.meas tran vdout1_54ck69 FIND v(dout1_54) AT=350.025n

* CHECK dout1_55 Vdout1_55ck69 = 0.9 time = 350
.meas tran vdout1_55ck69 FIND v(dout1_55) AT=350.025n

* CHECK dout1_56 Vdout1_56ck69 = 0 time = 350
.meas tran vdout1_56ck69 FIND v(dout1_56) AT=350.025n

* CHECK dout1_57 Vdout1_57ck69 = 0 time = 350
.meas tran vdout1_57ck69 FIND v(dout1_57) AT=350.025n

* CHECK dout1_58 Vdout1_58ck69 = 0 time = 350
.meas tran vdout1_58ck69 FIND v(dout1_58) AT=350.025n

* CHECK dout1_59 Vdout1_59ck69 = 0.9 time = 350
.meas tran vdout1_59ck69 FIND v(dout1_59) AT=350.025n

* CHECK dout1_60 Vdout1_60ck69 = 0.9 time = 350
.meas tran vdout1_60ck69 FIND v(dout1_60) AT=350.025n

* CHECK dout1_61 Vdout1_61ck69 = 0 time = 350
.meas tran vdout1_61ck69 FIND v(dout1_61) AT=350.025n

* CHECK dout1_62 Vdout1_62ck69 = 0 time = 350
.meas tran vdout1_62ck69 FIND v(dout1_62) AT=350.025n

* CHECK dout1_63 Vdout1_63ck69 = 0 time = 350
.meas tran vdout1_63ck69 FIND v(dout1_63) AT=350.025n

* CHECK dout1_64 Vdout1_64ck69 = 0 time = 350
.meas tran vdout1_64ck69 FIND v(dout1_64) AT=350.025n

* CHECK dout1_65 Vdout1_65ck69 = 0.9 time = 350
.meas tran vdout1_65ck69 FIND v(dout1_65) AT=350.025n

* CHECK dout1_66 Vdout1_66ck69 = 0 time = 350
.meas tran vdout1_66ck69 FIND v(dout1_66) AT=350.025n

* CHECK dout1_67 Vdout1_67ck69 = 0.9 time = 350
.meas tran vdout1_67ck69 FIND v(dout1_67) AT=350.025n

* CHECK dout1_68 Vdout1_68ck69 = 0 time = 350
.meas tran vdout1_68ck69 FIND v(dout1_68) AT=350.025n

* CHECK dout1_69 Vdout1_69ck69 = 0.9 time = 350
.meas tran vdout1_69ck69 FIND v(dout1_69) AT=350.025n

* CHECK dout1_70 Vdout1_70ck69 = 0 time = 350
.meas tran vdout1_70ck69 FIND v(dout1_70) AT=350.025n

* CHECK dout1_71 Vdout1_71ck69 = 0.9 time = 350
.meas tran vdout1_71ck69 FIND v(dout1_71) AT=350.025n

* CHECK dout1_72 Vdout1_72ck69 = 0 time = 350
.meas tran vdout1_72ck69 FIND v(dout1_72) AT=350.025n

* CHECK dout1_73 Vdout1_73ck69 = 0 time = 350
.meas tran vdout1_73ck69 FIND v(dout1_73) AT=350.025n

* CHECK dout1_74 Vdout1_74ck69 = 0 time = 350
.meas tran vdout1_74ck69 FIND v(dout1_74) AT=350.025n

* CHECK dout1_75 Vdout1_75ck69 = 0 time = 350
.meas tran vdout1_75ck69 FIND v(dout1_75) AT=350.025n

* CHECK dout1_76 Vdout1_76ck69 = 0 time = 350
.meas tran vdout1_76ck69 FIND v(dout1_76) AT=350.025n

* CHECK dout1_77 Vdout1_77ck69 = 0 time = 350
.meas tran vdout1_77ck69 FIND v(dout1_77) AT=350.025n

* CHECK dout1_78 Vdout1_78ck69 = 0.9 time = 350
.meas tran vdout1_78ck69 FIND v(dout1_78) AT=350.025n

* CHECK dout1_79 Vdout1_79ck69 = 0.9 time = 350
.meas tran vdout1_79ck69 FIND v(dout1_79) AT=350.025n

* CHECK dout1_80 Vdout1_80ck69 = 0.9 time = 350
.meas tran vdout1_80ck69 FIND v(dout1_80) AT=350.025n

* CHECK dout1_81 Vdout1_81ck69 = 0.9 time = 350
.meas tran vdout1_81ck69 FIND v(dout1_81) AT=350.025n

* CHECK dout1_82 Vdout1_82ck69 = 0.9 time = 350
.meas tran vdout1_82ck69 FIND v(dout1_82) AT=350.025n

* CHECK dout1_83 Vdout1_83ck69 = 0.9 time = 350
.meas tran vdout1_83ck69 FIND v(dout1_83) AT=350.025n

* CHECK dout1_84 Vdout1_84ck69 = 0.9 time = 350
.meas tran vdout1_84ck69 FIND v(dout1_84) AT=350.025n

* CHECK dout1_85 Vdout1_85ck69 = 0 time = 350
.meas tran vdout1_85ck69 FIND v(dout1_85) AT=350.025n

* CHECK dout1_86 Vdout1_86ck69 = 0.9 time = 350
.meas tran vdout1_86ck69 FIND v(dout1_86) AT=350.025n

* CHECK dout1_87 Vdout1_87ck69 = 0 time = 350
.meas tran vdout1_87ck69 FIND v(dout1_87) AT=350.025n

* CHECK dout1_88 Vdout1_88ck69 = 0 time = 350
.meas tran vdout1_88ck69 FIND v(dout1_88) AT=350.025n

* CHECK dout1_89 Vdout1_89ck69 = 0 time = 350
.meas tran vdout1_89ck69 FIND v(dout1_89) AT=350.025n

* CHECK dout1_90 Vdout1_90ck69 = 0 time = 350
.meas tran vdout1_90ck69 FIND v(dout1_90) AT=350.025n

* CHECK dout1_91 Vdout1_91ck69 = 0 time = 350
.meas tran vdout1_91ck69 FIND v(dout1_91) AT=350.025n

* CHECK dout1_92 Vdout1_92ck69 = 0 time = 350
.meas tran vdout1_92ck69 FIND v(dout1_92) AT=350.025n

* CHECK dout1_93 Vdout1_93ck69 = 0.9 time = 350
.meas tran vdout1_93ck69 FIND v(dout1_93) AT=350.025n

* CHECK dout1_94 Vdout1_94ck69 = 0 time = 350
.meas tran vdout1_94ck69 FIND v(dout1_94) AT=350.025n

* CHECK dout1_95 Vdout1_95ck69 = 0 time = 350
.meas tran vdout1_95ck69 FIND v(dout1_95) AT=350.025n

* CHECK dout1_96 Vdout1_96ck69 = 0.9 time = 350
.meas tran vdout1_96ck69 FIND v(dout1_96) AT=350.025n

* CHECK dout1_97 Vdout1_97ck69 = 0 time = 350
.meas tran vdout1_97ck69 FIND v(dout1_97) AT=350.025n

* CHECK dout1_98 Vdout1_98ck69 = 0 time = 350
.meas tran vdout1_98ck69 FIND v(dout1_98) AT=350.025n

* CHECK dout1_99 Vdout1_99ck69 = 0 time = 350
.meas tran vdout1_99ck69 FIND v(dout1_99) AT=350.025n

* CHECK dout1_100 Vdout1_100ck69 = 0 time = 350
.meas tran vdout1_100ck69 FIND v(dout1_100) AT=350.025n

* CHECK dout1_101 Vdout1_101ck69 = 0 time = 350
.meas tran vdout1_101ck69 FIND v(dout1_101) AT=350.025n

* CHECK dout1_102 Vdout1_102ck69 = 0 time = 350
.meas tran vdout1_102ck69 FIND v(dout1_102) AT=350.025n

* CHECK dout1_103 Vdout1_103ck69 = 0.9 time = 350
.meas tran vdout1_103ck69 FIND v(dout1_103) AT=350.025n

* CHECK dout1_104 Vdout1_104ck69 = 0.9 time = 350
.meas tran vdout1_104ck69 FIND v(dout1_104) AT=350.025n

* CHECK dout1_105 Vdout1_105ck69 = 0 time = 350
.meas tran vdout1_105ck69 FIND v(dout1_105) AT=350.025n

* CHECK dout1_106 Vdout1_106ck69 = 0.9 time = 350
.meas tran vdout1_106ck69 FIND v(dout1_106) AT=350.025n

* CHECK dout1_107 Vdout1_107ck69 = 0.9 time = 350
.meas tran vdout1_107ck69 FIND v(dout1_107) AT=350.025n

* CHECK dout1_108 Vdout1_108ck69 = 0.9 time = 350
.meas tran vdout1_108ck69 FIND v(dout1_108) AT=350.025n

* CHECK dout1_109 Vdout1_109ck69 = 0.9 time = 350
.meas tran vdout1_109ck69 FIND v(dout1_109) AT=350.025n

* CHECK dout1_110 Vdout1_110ck69 = 0.9 time = 350
.meas tran vdout1_110ck69 FIND v(dout1_110) AT=350.025n

* CHECK dout1_111 Vdout1_111ck69 = 0.9 time = 350
.meas tran vdout1_111ck69 FIND v(dout1_111) AT=350.025n

* CHECK dout1_112 Vdout1_112ck69 = 0.9 time = 350
.meas tran vdout1_112ck69 FIND v(dout1_112) AT=350.025n

* CHECK dout1_113 Vdout1_113ck69 = 0 time = 350
.meas tran vdout1_113ck69 FIND v(dout1_113) AT=350.025n

* CHECK dout1_114 Vdout1_114ck69 = 0 time = 350
.meas tran vdout1_114ck69 FIND v(dout1_114) AT=350.025n

* CHECK dout1_115 Vdout1_115ck69 = 0 time = 350
.meas tran vdout1_115ck69 FIND v(dout1_115) AT=350.025n

* CHECK dout1_116 Vdout1_116ck69 = 0.9 time = 350
.meas tran vdout1_116ck69 FIND v(dout1_116) AT=350.025n

* CHECK dout1_117 Vdout1_117ck69 = 0.9 time = 350
.meas tran vdout1_117ck69 FIND v(dout1_117) AT=350.025n

* CHECK dout1_118 Vdout1_118ck69 = 0.9 time = 350
.meas tran vdout1_118ck69 FIND v(dout1_118) AT=350.025n

* CHECK dout1_119 Vdout1_119ck69 = 0.9 time = 350
.meas tran vdout1_119ck69 FIND v(dout1_119) AT=350.025n

* CHECK dout1_0 Vdout1_0ck70 = 0.9 time = 355
.meas tran vdout1_0ck70 FIND v(dout1_0) AT=355.025n

* CHECK dout1_1 Vdout1_1ck70 = 0 time = 355
.meas tran vdout1_1ck70 FIND v(dout1_1) AT=355.025n

* CHECK dout1_2 Vdout1_2ck70 = 0 time = 355
.meas tran vdout1_2ck70 FIND v(dout1_2) AT=355.025n

* CHECK dout1_3 Vdout1_3ck70 = 0 time = 355
.meas tran vdout1_3ck70 FIND v(dout1_3) AT=355.025n

* CHECK dout1_4 Vdout1_4ck70 = 0 time = 355
.meas tran vdout1_4ck70 FIND v(dout1_4) AT=355.025n

* CHECK dout1_5 Vdout1_5ck70 = 0 time = 355
.meas tran vdout1_5ck70 FIND v(dout1_5) AT=355.025n

* CHECK dout1_6 Vdout1_6ck70 = 0 time = 355
.meas tran vdout1_6ck70 FIND v(dout1_6) AT=355.025n

* CHECK dout1_7 Vdout1_7ck70 = 0.9 time = 355
.meas tran vdout1_7ck70 FIND v(dout1_7) AT=355.025n

* CHECK dout1_8 Vdout1_8ck70 = 0 time = 355
.meas tran vdout1_8ck70 FIND v(dout1_8) AT=355.025n

* CHECK dout1_9 Vdout1_9ck70 = 0 time = 355
.meas tran vdout1_9ck70 FIND v(dout1_9) AT=355.025n

* CHECK dout1_10 Vdout1_10ck70 = 0 time = 355
.meas tran vdout1_10ck70 FIND v(dout1_10) AT=355.025n

* CHECK dout1_11 Vdout1_11ck70 = 0 time = 355
.meas tran vdout1_11ck70 FIND v(dout1_11) AT=355.025n

* CHECK dout1_12 Vdout1_12ck70 = 0 time = 355
.meas tran vdout1_12ck70 FIND v(dout1_12) AT=355.025n

* CHECK dout1_13 Vdout1_13ck70 = 0.9 time = 355
.meas tran vdout1_13ck70 FIND v(dout1_13) AT=355.025n

* CHECK dout1_14 Vdout1_14ck70 = 0 time = 355
.meas tran vdout1_14ck70 FIND v(dout1_14) AT=355.025n

* CHECK dout1_15 Vdout1_15ck70 = 0.9 time = 355
.meas tran vdout1_15ck70 FIND v(dout1_15) AT=355.025n

* CHECK dout1_16 Vdout1_16ck70 = 0.9 time = 355
.meas tran vdout1_16ck70 FIND v(dout1_16) AT=355.025n

* CHECK dout1_17 Vdout1_17ck70 = 0 time = 355
.meas tran vdout1_17ck70 FIND v(dout1_17) AT=355.025n

* CHECK dout1_18 Vdout1_18ck70 = 0.9 time = 355
.meas tran vdout1_18ck70 FIND v(dout1_18) AT=355.025n

* CHECK dout1_19 Vdout1_19ck70 = 0 time = 355
.meas tran vdout1_19ck70 FIND v(dout1_19) AT=355.025n

* CHECK dout1_20 Vdout1_20ck70 = 0.9 time = 355
.meas tran vdout1_20ck70 FIND v(dout1_20) AT=355.025n

* CHECK dout1_21 Vdout1_21ck70 = 0 time = 355
.meas tran vdout1_21ck70 FIND v(dout1_21) AT=355.025n

* CHECK dout1_22 Vdout1_22ck70 = 0.9 time = 355
.meas tran vdout1_22ck70 FIND v(dout1_22) AT=355.025n

* CHECK dout1_23 Vdout1_23ck70 = 0.9 time = 355
.meas tran vdout1_23ck70 FIND v(dout1_23) AT=355.025n

* CHECK dout1_24 Vdout1_24ck70 = 0.9 time = 355
.meas tran vdout1_24ck70 FIND v(dout1_24) AT=355.025n

* CHECK dout1_25 Vdout1_25ck70 = 0.9 time = 355
.meas tran vdout1_25ck70 FIND v(dout1_25) AT=355.025n

* CHECK dout1_26 Vdout1_26ck70 = 0.9 time = 355
.meas tran vdout1_26ck70 FIND v(dout1_26) AT=355.025n

* CHECK dout1_27 Vdout1_27ck70 = 0.9 time = 355
.meas tran vdout1_27ck70 FIND v(dout1_27) AT=355.025n

* CHECK dout1_28 Vdout1_28ck70 = 0 time = 355
.meas tran vdout1_28ck70 FIND v(dout1_28) AT=355.025n

* CHECK dout1_29 Vdout1_29ck70 = 0 time = 355
.meas tran vdout1_29ck70 FIND v(dout1_29) AT=355.025n

* CHECK dout1_30 Vdout1_30ck70 = 0.9 time = 355
.meas tran vdout1_30ck70 FIND v(dout1_30) AT=355.025n

* CHECK dout1_31 Vdout1_31ck70 = 0.9 time = 355
.meas tran vdout1_31ck70 FIND v(dout1_31) AT=355.025n

* CHECK dout1_32 Vdout1_32ck70 = 0.9 time = 355
.meas tran vdout1_32ck70 FIND v(dout1_32) AT=355.025n

* CHECK dout1_33 Vdout1_33ck70 = 0 time = 355
.meas tran vdout1_33ck70 FIND v(dout1_33) AT=355.025n

* CHECK dout1_34 Vdout1_34ck70 = 0 time = 355
.meas tran vdout1_34ck70 FIND v(dout1_34) AT=355.025n

* CHECK dout1_35 Vdout1_35ck70 = 0 time = 355
.meas tran vdout1_35ck70 FIND v(dout1_35) AT=355.025n

* CHECK dout1_36 Vdout1_36ck70 = 0 time = 355
.meas tran vdout1_36ck70 FIND v(dout1_36) AT=355.025n

* CHECK dout1_37 Vdout1_37ck70 = 0 time = 355
.meas tran vdout1_37ck70 FIND v(dout1_37) AT=355.025n

* CHECK dout1_38 Vdout1_38ck70 = 0 time = 355
.meas tran vdout1_38ck70 FIND v(dout1_38) AT=355.025n

* CHECK dout1_39 Vdout1_39ck70 = 0.9 time = 355
.meas tran vdout1_39ck70 FIND v(dout1_39) AT=355.025n

* CHECK dout1_40 Vdout1_40ck70 = 0 time = 355
.meas tran vdout1_40ck70 FIND v(dout1_40) AT=355.025n

* CHECK dout1_41 Vdout1_41ck70 = 0 time = 355
.meas tran vdout1_41ck70 FIND v(dout1_41) AT=355.025n

* CHECK dout1_42 Vdout1_42ck70 = 0.9 time = 355
.meas tran vdout1_42ck70 FIND v(dout1_42) AT=355.025n

* CHECK dout1_43 Vdout1_43ck70 = 0.9 time = 355
.meas tran vdout1_43ck70 FIND v(dout1_43) AT=355.025n

* CHECK dout1_44 Vdout1_44ck70 = 0 time = 355
.meas tran vdout1_44ck70 FIND v(dout1_44) AT=355.025n

* CHECK dout1_45 Vdout1_45ck70 = 0.9 time = 355
.meas tran vdout1_45ck70 FIND v(dout1_45) AT=355.025n

* CHECK dout1_46 Vdout1_46ck70 = 0 time = 355
.meas tran vdout1_46ck70 FIND v(dout1_46) AT=355.025n

* CHECK dout1_47 Vdout1_47ck70 = 0 time = 355
.meas tran vdout1_47ck70 FIND v(dout1_47) AT=355.025n

* CHECK dout1_48 Vdout1_48ck70 = 0 time = 355
.meas tran vdout1_48ck70 FIND v(dout1_48) AT=355.025n

* CHECK dout1_49 Vdout1_49ck70 = 0.9 time = 355
.meas tran vdout1_49ck70 FIND v(dout1_49) AT=355.025n

* CHECK dout1_50 Vdout1_50ck70 = 0 time = 355
.meas tran vdout1_50ck70 FIND v(dout1_50) AT=355.025n

* CHECK dout1_51 Vdout1_51ck70 = 0.9 time = 355
.meas tran vdout1_51ck70 FIND v(dout1_51) AT=355.025n

* CHECK dout1_52 Vdout1_52ck70 = 0 time = 355
.meas tran vdout1_52ck70 FIND v(dout1_52) AT=355.025n

* CHECK dout1_53 Vdout1_53ck70 = 0.9 time = 355
.meas tran vdout1_53ck70 FIND v(dout1_53) AT=355.025n

* CHECK dout1_54 Vdout1_54ck70 = 0.9 time = 355
.meas tran vdout1_54ck70 FIND v(dout1_54) AT=355.025n

* CHECK dout1_55 Vdout1_55ck70 = 0.9 time = 355
.meas tran vdout1_55ck70 FIND v(dout1_55) AT=355.025n

* CHECK dout1_56 Vdout1_56ck70 = 0 time = 355
.meas tran vdout1_56ck70 FIND v(dout1_56) AT=355.025n

* CHECK dout1_57 Vdout1_57ck70 = 0 time = 355
.meas tran vdout1_57ck70 FIND v(dout1_57) AT=355.025n

* CHECK dout1_58 Vdout1_58ck70 = 0 time = 355
.meas tran vdout1_58ck70 FIND v(dout1_58) AT=355.025n

* CHECK dout1_59 Vdout1_59ck70 = 0.9 time = 355
.meas tran vdout1_59ck70 FIND v(dout1_59) AT=355.025n

* CHECK dout1_60 Vdout1_60ck70 = 0.9 time = 355
.meas tran vdout1_60ck70 FIND v(dout1_60) AT=355.025n

* CHECK dout1_61 Vdout1_61ck70 = 0 time = 355
.meas tran vdout1_61ck70 FIND v(dout1_61) AT=355.025n

* CHECK dout1_62 Vdout1_62ck70 = 0 time = 355
.meas tran vdout1_62ck70 FIND v(dout1_62) AT=355.025n

* CHECK dout1_63 Vdout1_63ck70 = 0 time = 355
.meas tran vdout1_63ck70 FIND v(dout1_63) AT=355.025n

* CHECK dout1_64 Vdout1_64ck70 = 0 time = 355
.meas tran vdout1_64ck70 FIND v(dout1_64) AT=355.025n

* CHECK dout1_65 Vdout1_65ck70 = 0.9 time = 355
.meas tran vdout1_65ck70 FIND v(dout1_65) AT=355.025n

* CHECK dout1_66 Vdout1_66ck70 = 0 time = 355
.meas tran vdout1_66ck70 FIND v(dout1_66) AT=355.025n

* CHECK dout1_67 Vdout1_67ck70 = 0.9 time = 355
.meas tran vdout1_67ck70 FIND v(dout1_67) AT=355.025n

* CHECK dout1_68 Vdout1_68ck70 = 0 time = 355
.meas tran vdout1_68ck70 FIND v(dout1_68) AT=355.025n

* CHECK dout1_69 Vdout1_69ck70 = 0.9 time = 355
.meas tran vdout1_69ck70 FIND v(dout1_69) AT=355.025n

* CHECK dout1_70 Vdout1_70ck70 = 0 time = 355
.meas tran vdout1_70ck70 FIND v(dout1_70) AT=355.025n

* CHECK dout1_71 Vdout1_71ck70 = 0.9 time = 355
.meas tran vdout1_71ck70 FIND v(dout1_71) AT=355.025n

* CHECK dout1_72 Vdout1_72ck70 = 0 time = 355
.meas tran vdout1_72ck70 FIND v(dout1_72) AT=355.025n

* CHECK dout1_73 Vdout1_73ck70 = 0 time = 355
.meas tran vdout1_73ck70 FIND v(dout1_73) AT=355.025n

* CHECK dout1_74 Vdout1_74ck70 = 0 time = 355
.meas tran vdout1_74ck70 FIND v(dout1_74) AT=355.025n

* CHECK dout1_75 Vdout1_75ck70 = 0 time = 355
.meas tran vdout1_75ck70 FIND v(dout1_75) AT=355.025n

* CHECK dout1_76 Vdout1_76ck70 = 0 time = 355
.meas tran vdout1_76ck70 FIND v(dout1_76) AT=355.025n

* CHECK dout1_77 Vdout1_77ck70 = 0 time = 355
.meas tran vdout1_77ck70 FIND v(dout1_77) AT=355.025n

* CHECK dout1_78 Vdout1_78ck70 = 0.9 time = 355
.meas tran vdout1_78ck70 FIND v(dout1_78) AT=355.025n

* CHECK dout1_79 Vdout1_79ck70 = 0.9 time = 355
.meas tran vdout1_79ck70 FIND v(dout1_79) AT=355.025n

* CHECK dout1_80 Vdout1_80ck70 = 0.9 time = 355
.meas tran vdout1_80ck70 FIND v(dout1_80) AT=355.025n

* CHECK dout1_81 Vdout1_81ck70 = 0.9 time = 355
.meas tran vdout1_81ck70 FIND v(dout1_81) AT=355.025n

* CHECK dout1_82 Vdout1_82ck70 = 0.9 time = 355
.meas tran vdout1_82ck70 FIND v(dout1_82) AT=355.025n

* CHECK dout1_83 Vdout1_83ck70 = 0.9 time = 355
.meas tran vdout1_83ck70 FIND v(dout1_83) AT=355.025n

* CHECK dout1_84 Vdout1_84ck70 = 0.9 time = 355
.meas tran vdout1_84ck70 FIND v(dout1_84) AT=355.025n

* CHECK dout1_85 Vdout1_85ck70 = 0 time = 355
.meas tran vdout1_85ck70 FIND v(dout1_85) AT=355.025n

* CHECK dout1_86 Vdout1_86ck70 = 0.9 time = 355
.meas tran vdout1_86ck70 FIND v(dout1_86) AT=355.025n

* CHECK dout1_87 Vdout1_87ck70 = 0 time = 355
.meas tran vdout1_87ck70 FIND v(dout1_87) AT=355.025n

* CHECK dout1_88 Vdout1_88ck70 = 0 time = 355
.meas tran vdout1_88ck70 FIND v(dout1_88) AT=355.025n

* CHECK dout1_89 Vdout1_89ck70 = 0 time = 355
.meas tran vdout1_89ck70 FIND v(dout1_89) AT=355.025n

* CHECK dout1_90 Vdout1_90ck70 = 0 time = 355
.meas tran vdout1_90ck70 FIND v(dout1_90) AT=355.025n

* CHECK dout1_91 Vdout1_91ck70 = 0 time = 355
.meas tran vdout1_91ck70 FIND v(dout1_91) AT=355.025n

* CHECK dout1_92 Vdout1_92ck70 = 0 time = 355
.meas tran vdout1_92ck70 FIND v(dout1_92) AT=355.025n

* CHECK dout1_93 Vdout1_93ck70 = 0.9 time = 355
.meas tran vdout1_93ck70 FIND v(dout1_93) AT=355.025n

* CHECK dout1_94 Vdout1_94ck70 = 0 time = 355
.meas tran vdout1_94ck70 FIND v(dout1_94) AT=355.025n

* CHECK dout1_95 Vdout1_95ck70 = 0 time = 355
.meas tran vdout1_95ck70 FIND v(dout1_95) AT=355.025n

* CHECK dout1_96 Vdout1_96ck70 = 0.9 time = 355
.meas tran vdout1_96ck70 FIND v(dout1_96) AT=355.025n

* CHECK dout1_97 Vdout1_97ck70 = 0 time = 355
.meas tran vdout1_97ck70 FIND v(dout1_97) AT=355.025n

* CHECK dout1_98 Vdout1_98ck70 = 0 time = 355
.meas tran vdout1_98ck70 FIND v(dout1_98) AT=355.025n

* CHECK dout1_99 Vdout1_99ck70 = 0 time = 355
.meas tran vdout1_99ck70 FIND v(dout1_99) AT=355.025n

* CHECK dout1_100 Vdout1_100ck70 = 0 time = 355
.meas tran vdout1_100ck70 FIND v(dout1_100) AT=355.025n

* CHECK dout1_101 Vdout1_101ck70 = 0 time = 355
.meas tran vdout1_101ck70 FIND v(dout1_101) AT=355.025n

* CHECK dout1_102 Vdout1_102ck70 = 0 time = 355
.meas tran vdout1_102ck70 FIND v(dout1_102) AT=355.025n

* CHECK dout1_103 Vdout1_103ck70 = 0.9 time = 355
.meas tran vdout1_103ck70 FIND v(dout1_103) AT=355.025n

* CHECK dout1_104 Vdout1_104ck70 = 0.9 time = 355
.meas tran vdout1_104ck70 FIND v(dout1_104) AT=355.025n

* CHECK dout1_105 Vdout1_105ck70 = 0 time = 355
.meas tran vdout1_105ck70 FIND v(dout1_105) AT=355.025n

* CHECK dout1_106 Vdout1_106ck70 = 0.9 time = 355
.meas tran vdout1_106ck70 FIND v(dout1_106) AT=355.025n

* CHECK dout1_107 Vdout1_107ck70 = 0.9 time = 355
.meas tran vdout1_107ck70 FIND v(dout1_107) AT=355.025n

* CHECK dout1_108 Vdout1_108ck70 = 0.9 time = 355
.meas tran vdout1_108ck70 FIND v(dout1_108) AT=355.025n

* CHECK dout1_109 Vdout1_109ck70 = 0.9 time = 355
.meas tran vdout1_109ck70 FIND v(dout1_109) AT=355.025n

* CHECK dout1_110 Vdout1_110ck70 = 0.9 time = 355
.meas tran vdout1_110ck70 FIND v(dout1_110) AT=355.025n

* CHECK dout1_111 Vdout1_111ck70 = 0.9 time = 355
.meas tran vdout1_111ck70 FIND v(dout1_111) AT=355.025n

* CHECK dout1_112 Vdout1_112ck70 = 0.9 time = 355
.meas tran vdout1_112ck70 FIND v(dout1_112) AT=355.025n

* CHECK dout1_113 Vdout1_113ck70 = 0 time = 355
.meas tran vdout1_113ck70 FIND v(dout1_113) AT=355.025n

* CHECK dout1_114 Vdout1_114ck70 = 0 time = 355
.meas tran vdout1_114ck70 FIND v(dout1_114) AT=355.025n

* CHECK dout1_115 Vdout1_115ck70 = 0 time = 355
.meas tran vdout1_115ck70 FIND v(dout1_115) AT=355.025n

* CHECK dout1_116 Vdout1_116ck70 = 0.9 time = 355
.meas tran vdout1_116ck70 FIND v(dout1_116) AT=355.025n

* CHECK dout1_117 Vdout1_117ck70 = 0.9 time = 355
.meas tran vdout1_117ck70 FIND v(dout1_117) AT=355.025n

* CHECK dout1_118 Vdout1_118ck70 = 0.9 time = 355
.meas tran vdout1_118ck70 FIND v(dout1_118) AT=355.025n

* CHECK dout1_119 Vdout1_119ck70 = 0.9 time = 355
.meas tran vdout1_119ck70 FIND v(dout1_119) AT=355.025n

* CHECK dout1_0 Vdout1_0ck76 = 0.9 time = 385
.meas tran vdout1_0ck76 FIND v(dout1_0) AT=385.025n

* CHECK dout1_1 Vdout1_1ck76 = 0.9 time = 385
.meas tran vdout1_1ck76 FIND v(dout1_1) AT=385.025n

* CHECK dout1_2 Vdout1_2ck76 = 0.9 time = 385
.meas tran vdout1_2ck76 FIND v(dout1_2) AT=385.025n

* CHECK dout1_3 Vdout1_3ck76 = 0 time = 385
.meas tran vdout1_3ck76 FIND v(dout1_3) AT=385.025n

* CHECK dout1_4 Vdout1_4ck76 = 0 time = 385
.meas tran vdout1_4ck76 FIND v(dout1_4) AT=385.025n

* CHECK dout1_5 Vdout1_5ck76 = 0 time = 385
.meas tran vdout1_5ck76 FIND v(dout1_5) AT=385.025n

* CHECK dout1_6 Vdout1_6ck76 = 0 time = 385
.meas tran vdout1_6ck76 FIND v(dout1_6) AT=385.025n

* CHECK dout1_7 Vdout1_7ck76 = 0.9 time = 385
.meas tran vdout1_7ck76 FIND v(dout1_7) AT=385.025n

* CHECK dout1_8 Vdout1_8ck76 = 0 time = 385
.meas tran vdout1_8ck76 FIND v(dout1_8) AT=385.025n

* CHECK dout1_9 Vdout1_9ck76 = 0.9 time = 385
.meas tran vdout1_9ck76 FIND v(dout1_9) AT=385.025n

* CHECK dout1_10 Vdout1_10ck76 = 0 time = 385
.meas tran vdout1_10ck76 FIND v(dout1_10) AT=385.025n

* CHECK dout1_11 Vdout1_11ck76 = 0.9 time = 385
.meas tran vdout1_11ck76 FIND v(dout1_11) AT=385.025n

* CHECK dout1_12 Vdout1_12ck76 = 0.9 time = 385
.meas tran vdout1_12ck76 FIND v(dout1_12) AT=385.025n

* CHECK dout1_13 Vdout1_13ck76 = 0.9 time = 385
.meas tran vdout1_13ck76 FIND v(dout1_13) AT=385.025n

* CHECK dout1_14 Vdout1_14ck76 = 0 time = 385
.meas tran vdout1_14ck76 FIND v(dout1_14) AT=385.025n

* CHECK dout1_15 Vdout1_15ck76 = 0 time = 385
.meas tran vdout1_15ck76 FIND v(dout1_15) AT=385.025n

* CHECK dout1_16 Vdout1_16ck76 = 0 time = 385
.meas tran vdout1_16ck76 FIND v(dout1_16) AT=385.025n

* CHECK dout1_17 Vdout1_17ck76 = 0 time = 385
.meas tran vdout1_17ck76 FIND v(dout1_17) AT=385.025n

* CHECK dout1_18 Vdout1_18ck76 = 0 time = 385
.meas tran vdout1_18ck76 FIND v(dout1_18) AT=385.025n

* CHECK dout1_19 Vdout1_19ck76 = 0.9 time = 385
.meas tran vdout1_19ck76 FIND v(dout1_19) AT=385.025n

* CHECK dout1_20 Vdout1_20ck76 = 0.9 time = 385
.meas tran vdout1_20ck76 FIND v(dout1_20) AT=385.025n

* CHECK dout1_21 Vdout1_21ck76 = 0 time = 385
.meas tran vdout1_21ck76 FIND v(dout1_21) AT=385.025n

* CHECK dout1_22 Vdout1_22ck76 = 0 time = 385
.meas tran vdout1_22ck76 FIND v(dout1_22) AT=385.025n

* CHECK dout1_23 Vdout1_23ck76 = 0.9 time = 385
.meas tran vdout1_23ck76 FIND v(dout1_23) AT=385.025n

* CHECK dout1_24 Vdout1_24ck76 = 0 time = 385
.meas tran vdout1_24ck76 FIND v(dout1_24) AT=385.025n

* CHECK dout1_25 Vdout1_25ck76 = 0.9 time = 385
.meas tran vdout1_25ck76 FIND v(dout1_25) AT=385.025n

* CHECK dout1_26 Vdout1_26ck76 = 0.9 time = 385
.meas tran vdout1_26ck76 FIND v(dout1_26) AT=385.025n

* CHECK dout1_27 Vdout1_27ck76 = 0.9 time = 385
.meas tran vdout1_27ck76 FIND v(dout1_27) AT=385.025n

* CHECK dout1_28 Vdout1_28ck76 = 0.9 time = 385
.meas tran vdout1_28ck76 FIND v(dout1_28) AT=385.025n

* CHECK dout1_29 Vdout1_29ck76 = 0.9 time = 385
.meas tran vdout1_29ck76 FIND v(dout1_29) AT=385.025n

* CHECK dout1_30 Vdout1_30ck76 = 0 time = 385
.meas tran vdout1_30ck76 FIND v(dout1_30) AT=385.025n

* CHECK dout1_31 Vdout1_31ck76 = 0.9 time = 385
.meas tran vdout1_31ck76 FIND v(dout1_31) AT=385.025n

* CHECK dout1_32 Vdout1_32ck76 = 0.9 time = 385
.meas tran vdout1_32ck76 FIND v(dout1_32) AT=385.025n

* CHECK dout1_33 Vdout1_33ck76 = 0.9 time = 385
.meas tran vdout1_33ck76 FIND v(dout1_33) AT=385.025n

* CHECK dout1_34 Vdout1_34ck76 = 0 time = 385
.meas tran vdout1_34ck76 FIND v(dout1_34) AT=385.025n

* CHECK dout1_35 Vdout1_35ck76 = 0.9 time = 385
.meas tran vdout1_35ck76 FIND v(dout1_35) AT=385.025n

* CHECK dout1_36 Vdout1_36ck76 = 0.9 time = 385
.meas tran vdout1_36ck76 FIND v(dout1_36) AT=385.025n

* CHECK dout1_37 Vdout1_37ck76 = 0.9 time = 385
.meas tran vdout1_37ck76 FIND v(dout1_37) AT=385.025n

* CHECK dout1_38 Vdout1_38ck76 = 0.9 time = 385
.meas tran vdout1_38ck76 FIND v(dout1_38) AT=385.025n

* CHECK dout1_39 Vdout1_39ck76 = 0.9 time = 385
.meas tran vdout1_39ck76 FIND v(dout1_39) AT=385.025n

* CHECK dout1_40 Vdout1_40ck76 = 0.9 time = 385
.meas tran vdout1_40ck76 FIND v(dout1_40) AT=385.025n

* CHECK dout1_41 Vdout1_41ck76 = 0 time = 385
.meas tran vdout1_41ck76 FIND v(dout1_41) AT=385.025n

* CHECK dout1_42 Vdout1_42ck76 = 0.9 time = 385
.meas tran vdout1_42ck76 FIND v(dout1_42) AT=385.025n

* CHECK dout1_43 Vdout1_43ck76 = 0.9 time = 385
.meas tran vdout1_43ck76 FIND v(dout1_43) AT=385.025n

* CHECK dout1_44 Vdout1_44ck76 = 0.9 time = 385
.meas tran vdout1_44ck76 FIND v(dout1_44) AT=385.025n

* CHECK dout1_45 Vdout1_45ck76 = 0.9 time = 385
.meas tran vdout1_45ck76 FIND v(dout1_45) AT=385.025n

* CHECK dout1_46 Vdout1_46ck76 = 0.9 time = 385
.meas tran vdout1_46ck76 FIND v(dout1_46) AT=385.025n

* CHECK dout1_47 Vdout1_47ck76 = 0.9 time = 385
.meas tran vdout1_47ck76 FIND v(dout1_47) AT=385.025n

* CHECK dout1_48 Vdout1_48ck76 = 0.9 time = 385
.meas tran vdout1_48ck76 FIND v(dout1_48) AT=385.025n

* CHECK dout1_49 Vdout1_49ck76 = 0 time = 385
.meas tran vdout1_49ck76 FIND v(dout1_49) AT=385.025n

* CHECK dout1_50 Vdout1_50ck76 = 0 time = 385
.meas tran vdout1_50ck76 FIND v(dout1_50) AT=385.025n

* CHECK dout1_51 Vdout1_51ck76 = 0.9 time = 385
.meas tran vdout1_51ck76 FIND v(dout1_51) AT=385.025n

* CHECK dout1_52 Vdout1_52ck76 = 0 time = 385
.meas tran vdout1_52ck76 FIND v(dout1_52) AT=385.025n

* CHECK dout1_53 Vdout1_53ck76 = 0.9 time = 385
.meas tran vdout1_53ck76 FIND v(dout1_53) AT=385.025n

* CHECK dout1_54 Vdout1_54ck76 = 0.9 time = 385
.meas tran vdout1_54ck76 FIND v(dout1_54) AT=385.025n

* CHECK dout1_55 Vdout1_55ck76 = 0 time = 385
.meas tran vdout1_55ck76 FIND v(dout1_55) AT=385.025n

* CHECK dout1_56 Vdout1_56ck76 = 0 time = 385
.meas tran vdout1_56ck76 FIND v(dout1_56) AT=385.025n

* CHECK dout1_57 Vdout1_57ck76 = 0 time = 385
.meas tran vdout1_57ck76 FIND v(dout1_57) AT=385.025n

* CHECK dout1_58 Vdout1_58ck76 = 0 time = 385
.meas tran vdout1_58ck76 FIND v(dout1_58) AT=385.025n

* CHECK dout1_59 Vdout1_59ck76 = 0.9 time = 385
.meas tran vdout1_59ck76 FIND v(dout1_59) AT=385.025n

* CHECK dout1_60 Vdout1_60ck76 = 0.9 time = 385
.meas tran vdout1_60ck76 FIND v(dout1_60) AT=385.025n

* CHECK dout1_61 Vdout1_61ck76 = 0 time = 385
.meas tran vdout1_61ck76 FIND v(dout1_61) AT=385.025n

* CHECK dout1_62 Vdout1_62ck76 = 0 time = 385
.meas tran vdout1_62ck76 FIND v(dout1_62) AT=385.025n

* CHECK dout1_63 Vdout1_63ck76 = 0 time = 385
.meas tran vdout1_63ck76 FIND v(dout1_63) AT=385.025n

* CHECK dout1_64 Vdout1_64ck76 = 0 time = 385
.meas tran vdout1_64ck76 FIND v(dout1_64) AT=385.025n

* CHECK dout1_65 Vdout1_65ck76 = 0.9 time = 385
.meas tran vdout1_65ck76 FIND v(dout1_65) AT=385.025n

* CHECK dout1_66 Vdout1_66ck76 = 0 time = 385
.meas tran vdout1_66ck76 FIND v(dout1_66) AT=385.025n

* CHECK dout1_67 Vdout1_67ck76 = 0.9 time = 385
.meas tran vdout1_67ck76 FIND v(dout1_67) AT=385.025n

* CHECK dout1_68 Vdout1_68ck76 = 0 time = 385
.meas tran vdout1_68ck76 FIND v(dout1_68) AT=385.025n

* CHECK dout1_69 Vdout1_69ck76 = 0.9 time = 385
.meas tran vdout1_69ck76 FIND v(dout1_69) AT=385.025n

* CHECK dout1_70 Vdout1_70ck76 = 0 time = 385
.meas tran vdout1_70ck76 FIND v(dout1_70) AT=385.025n

* CHECK dout1_71 Vdout1_71ck76 = 0.9 time = 385
.meas tran vdout1_71ck76 FIND v(dout1_71) AT=385.025n

* CHECK dout1_72 Vdout1_72ck76 = 0 time = 385
.meas tran vdout1_72ck76 FIND v(dout1_72) AT=385.025n

* CHECK dout1_73 Vdout1_73ck76 = 0 time = 385
.meas tran vdout1_73ck76 FIND v(dout1_73) AT=385.025n

* CHECK dout1_74 Vdout1_74ck76 = 0 time = 385
.meas tran vdout1_74ck76 FIND v(dout1_74) AT=385.025n

* CHECK dout1_75 Vdout1_75ck76 = 0 time = 385
.meas tran vdout1_75ck76 FIND v(dout1_75) AT=385.025n

* CHECK dout1_76 Vdout1_76ck76 = 0 time = 385
.meas tran vdout1_76ck76 FIND v(dout1_76) AT=385.025n

* CHECK dout1_77 Vdout1_77ck76 = 0 time = 385
.meas tran vdout1_77ck76 FIND v(dout1_77) AT=385.025n

* CHECK dout1_78 Vdout1_78ck76 = 0.9 time = 385
.meas tran vdout1_78ck76 FIND v(dout1_78) AT=385.025n

* CHECK dout1_79 Vdout1_79ck76 = 0.9 time = 385
.meas tran vdout1_79ck76 FIND v(dout1_79) AT=385.025n

* CHECK dout1_80 Vdout1_80ck76 = 0.9 time = 385
.meas tran vdout1_80ck76 FIND v(dout1_80) AT=385.025n

* CHECK dout1_81 Vdout1_81ck76 = 0.9 time = 385
.meas tran vdout1_81ck76 FIND v(dout1_81) AT=385.025n

* CHECK dout1_82 Vdout1_82ck76 = 0.9 time = 385
.meas tran vdout1_82ck76 FIND v(dout1_82) AT=385.025n

* CHECK dout1_83 Vdout1_83ck76 = 0.9 time = 385
.meas tran vdout1_83ck76 FIND v(dout1_83) AT=385.025n

* CHECK dout1_84 Vdout1_84ck76 = 0.9 time = 385
.meas tran vdout1_84ck76 FIND v(dout1_84) AT=385.025n

* CHECK dout1_85 Vdout1_85ck76 = 0 time = 385
.meas tran vdout1_85ck76 FIND v(dout1_85) AT=385.025n

* CHECK dout1_86 Vdout1_86ck76 = 0.9 time = 385
.meas tran vdout1_86ck76 FIND v(dout1_86) AT=385.025n

* CHECK dout1_87 Vdout1_87ck76 = 0 time = 385
.meas tran vdout1_87ck76 FIND v(dout1_87) AT=385.025n

* CHECK dout1_88 Vdout1_88ck76 = 0 time = 385
.meas tran vdout1_88ck76 FIND v(dout1_88) AT=385.025n

* CHECK dout1_89 Vdout1_89ck76 = 0 time = 385
.meas tran vdout1_89ck76 FIND v(dout1_89) AT=385.025n

* CHECK dout1_90 Vdout1_90ck76 = 0 time = 385
.meas tran vdout1_90ck76 FIND v(dout1_90) AT=385.025n

* CHECK dout1_91 Vdout1_91ck76 = 0 time = 385
.meas tran vdout1_91ck76 FIND v(dout1_91) AT=385.025n

* CHECK dout1_92 Vdout1_92ck76 = 0 time = 385
.meas tran vdout1_92ck76 FIND v(dout1_92) AT=385.025n

* CHECK dout1_93 Vdout1_93ck76 = 0.9 time = 385
.meas tran vdout1_93ck76 FIND v(dout1_93) AT=385.025n

* CHECK dout1_94 Vdout1_94ck76 = 0 time = 385
.meas tran vdout1_94ck76 FIND v(dout1_94) AT=385.025n

* CHECK dout1_95 Vdout1_95ck76 = 0 time = 385
.meas tran vdout1_95ck76 FIND v(dout1_95) AT=385.025n

* CHECK dout1_96 Vdout1_96ck76 = 0.9 time = 385
.meas tran vdout1_96ck76 FIND v(dout1_96) AT=385.025n

* CHECK dout1_97 Vdout1_97ck76 = 0 time = 385
.meas tran vdout1_97ck76 FIND v(dout1_97) AT=385.025n

* CHECK dout1_98 Vdout1_98ck76 = 0 time = 385
.meas tran vdout1_98ck76 FIND v(dout1_98) AT=385.025n

* CHECK dout1_99 Vdout1_99ck76 = 0 time = 385
.meas tran vdout1_99ck76 FIND v(dout1_99) AT=385.025n

* CHECK dout1_100 Vdout1_100ck76 = 0 time = 385
.meas tran vdout1_100ck76 FIND v(dout1_100) AT=385.025n

* CHECK dout1_101 Vdout1_101ck76 = 0 time = 385
.meas tran vdout1_101ck76 FIND v(dout1_101) AT=385.025n

* CHECK dout1_102 Vdout1_102ck76 = 0 time = 385
.meas tran vdout1_102ck76 FIND v(dout1_102) AT=385.025n

* CHECK dout1_103 Vdout1_103ck76 = 0.9 time = 385
.meas tran vdout1_103ck76 FIND v(dout1_103) AT=385.025n

* CHECK dout1_104 Vdout1_104ck76 = 0.9 time = 385
.meas tran vdout1_104ck76 FIND v(dout1_104) AT=385.025n

* CHECK dout1_105 Vdout1_105ck76 = 0 time = 385
.meas tran vdout1_105ck76 FIND v(dout1_105) AT=385.025n

* CHECK dout1_106 Vdout1_106ck76 = 0.9 time = 385
.meas tran vdout1_106ck76 FIND v(dout1_106) AT=385.025n

* CHECK dout1_107 Vdout1_107ck76 = 0.9 time = 385
.meas tran vdout1_107ck76 FIND v(dout1_107) AT=385.025n

* CHECK dout1_108 Vdout1_108ck76 = 0.9 time = 385
.meas tran vdout1_108ck76 FIND v(dout1_108) AT=385.025n

* CHECK dout1_109 Vdout1_109ck76 = 0.9 time = 385
.meas tran vdout1_109ck76 FIND v(dout1_109) AT=385.025n

* CHECK dout1_110 Vdout1_110ck76 = 0.9 time = 385
.meas tran vdout1_110ck76 FIND v(dout1_110) AT=385.025n

* CHECK dout1_111 Vdout1_111ck76 = 0.9 time = 385
.meas tran vdout1_111ck76 FIND v(dout1_111) AT=385.025n

* CHECK dout1_112 Vdout1_112ck76 = 0.9 time = 385
.meas tran vdout1_112ck76 FIND v(dout1_112) AT=385.025n

* CHECK dout1_113 Vdout1_113ck76 = 0 time = 385
.meas tran vdout1_113ck76 FIND v(dout1_113) AT=385.025n

* CHECK dout1_114 Vdout1_114ck76 = 0 time = 385
.meas tran vdout1_114ck76 FIND v(dout1_114) AT=385.025n

* CHECK dout1_115 Vdout1_115ck76 = 0 time = 385
.meas tran vdout1_115ck76 FIND v(dout1_115) AT=385.025n

* CHECK dout1_116 Vdout1_116ck76 = 0.9 time = 385
.meas tran vdout1_116ck76 FIND v(dout1_116) AT=385.025n

* CHECK dout1_117 Vdout1_117ck76 = 0.9 time = 385
.meas tran vdout1_117ck76 FIND v(dout1_117) AT=385.025n

* CHECK dout1_118 Vdout1_118ck76 = 0.9 time = 385
.meas tran vdout1_118ck76 FIND v(dout1_118) AT=385.025n

* CHECK dout1_119 Vdout1_119ck76 = 0.9 time = 385
.meas tran vdout1_119ck76 FIND v(dout1_119) AT=385.025n

* CHECK dout1_0 Vdout1_0ck86 = 0.9 time = 435
.meas tran vdout1_0ck86 FIND v(dout1_0) AT=435.025n

* CHECK dout1_1 Vdout1_1ck86 = 0 time = 435
.meas tran vdout1_1ck86 FIND v(dout1_1) AT=435.025n

* CHECK dout1_2 Vdout1_2ck86 = 0.9 time = 435
.meas tran vdout1_2ck86 FIND v(dout1_2) AT=435.025n

* CHECK dout1_3 Vdout1_3ck86 = 0.9 time = 435
.meas tran vdout1_3ck86 FIND v(dout1_3) AT=435.025n

* CHECK dout1_4 Vdout1_4ck86 = 0 time = 435
.meas tran vdout1_4ck86 FIND v(dout1_4) AT=435.025n

* CHECK dout1_5 Vdout1_5ck86 = 0 time = 435
.meas tran vdout1_5ck86 FIND v(dout1_5) AT=435.025n

* CHECK dout1_6 Vdout1_6ck86 = 0 time = 435
.meas tran vdout1_6ck86 FIND v(dout1_6) AT=435.025n

* CHECK dout1_7 Vdout1_7ck86 = 0.9 time = 435
.meas tran vdout1_7ck86 FIND v(dout1_7) AT=435.025n

* CHECK dout1_8 Vdout1_8ck86 = 0 time = 435
.meas tran vdout1_8ck86 FIND v(dout1_8) AT=435.025n

* CHECK dout1_9 Vdout1_9ck86 = 0.9 time = 435
.meas tran vdout1_9ck86 FIND v(dout1_9) AT=435.025n

* CHECK dout1_10 Vdout1_10ck86 = 0 time = 435
.meas tran vdout1_10ck86 FIND v(dout1_10) AT=435.025n

* CHECK dout1_11 Vdout1_11ck86 = 0 time = 435
.meas tran vdout1_11ck86 FIND v(dout1_11) AT=435.025n

* CHECK dout1_12 Vdout1_12ck86 = 0 time = 435
.meas tran vdout1_12ck86 FIND v(dout1_12) AT=435.025n

* CHECK dout1_13 Vdout1_13ck86 = 0.9 time = 435
.meas tran vdout1_13ck86 FIND v(dout1_13) AT=435.025n

* CHECK dout1_14 Vdout1_14ck86 = 0 time = 435
.meas tran vdout1_14ck86 FIND v(dout1_14) AT=435.025n

* CHECK dout1_15 Vdout1_15ck86 = 0.9 time = 435
.meas tran vdout1_15ck86 FIND v(dout1_15) AT=435.025n

* CHECK dout1_16 Vdout1_16ck86 = 0 time = 435
.meas tran vdout1_16ck86 FIND v(dout1_16) AT=435.025n

* CHECK dout1_17 Vdout1_17ck86 = 0.9 time = 435
.meas tran vdout1_17ck86 FIND v(dout1_17) AT=435.025n

* CHECK dout1_18 Vdout1_18ck86 = 0.9 time = 435
.meas tran vdout1_18ck86 FIND v(dout1_18) AT=435.025n

* CHECK dout1_19 Vdout1_19ck86 = 0.9 time = 435
.meas tran vdout1_19ck86 FIND v(dout1_19) AT=435.025n

* CHECK dout1_20 Vdout1_20ck86 = 0.9 time = 435
.meas tran vdout1_20ck86 FIND v(dout1_20) AT=435.025n

* CHECK dout1_21 Vdout1_21ck86 = 0.9 time = 435
.meas tran vdout1_21ck86 FIND v(dout1_21) AT=435.025n

* CHECK dout1_22 Vdout1_22ck86 = 0.9 time = 435
.meas tran vdout1_22ck86 FIND v(dout1_22) AT=435.025n

* CHECK dout1_23 Vdout1_23ck86 = 0.9 time = 435
.meas tran vdout1_23ck86 FIND v(dout1_23) AT=435.025n

* CHECK dout1_24 Vdout1_24ck86 = 0 time = 435
.meas tran vdout1_24ck86 FIND v(dout1_24) AT=435.025n

* CHECK dout1_25 Vdout1_25ck86 = 0.9 time = 435
.meas tran vdout1_25ck86 FIND v(dout1_25) AT=435.025n

* CHECK dout1_26 Vdout1_26ck86 = 0 time = 435
.meas tran vdout1_26ck86 FIND v(dout1_26) AT=435.025n

* CHECK dout1_27 Vdout1_27ck86 = 0 time = 435
.meas tran vdout1_27ck86 FIND v(dout1_27) AT=435.025n

* CHECK dout1_28 Vdout1_28ck86 = 0 time = 435
.meas tran vdout1_28ck86 FIND v(dout1_28) AT=435.025n

* CHECK dout1_29 Vdout1_29ck86 = 0 time = 435
.meas tran vdout1_29ck86 FIND v(dout1_29) AT=435.025n

* CHECK dout1_30 Vdout1_30ck86 = 0 time = 435
.meas tran vdout1_30ck86 FIND v(dout1_30) AT=435.025n

* CHECK dout1_31 Vdout1_31ck86 = 0 time = 435
.meas tran vdout1_31ck86 FIND v(dout1_31) AT=435.025n

* CHECK dout1_32 Vdout1_32ck86 = 0 time = 435
.meas tran vdout1_32ck86 FIND v(dout1_32) AT=435.025n

* CHECK dout1_33 Vdout1_33ck86 = 0.9 time = 435
.meas tran vdout1_33ck86 FIND v(dout1_33) AT=435.025n

* CHECK dout1_34 Vdout1_34ck86 = 0 time = 435
.meas tran vdout1_34ck86 FIND v(dout1_34) AT=435.025n

* CHECK dout1_35 Vdout1_35ck86 = 0.9 time = 435
.meas tran vdout1_35ck86 FIND v(dout1_35) AT=435.025n

* CHECK dout1_36 Vdout1_36ck86 = 0.9 time = 435
.meas tran vdout1_36ck86 FIND v(dout1_36) AT=435.025n

* CHECK dout1_37 Vdout1_37ck86 = 0 time = 435
.meas tran vdout1_37ck86 FIND v(dout1_37) AT=435.025n

* CHECK dout1_38 Vdout1_38ck86 = 0 time = 435
.meas tran vdout1_38ck86 FIND v(dout1_38) AT=435.025n

* CHECK dout1_39 Vdout1_39ck86 = 0.9 time = 435
.meas tran vdout1_39ck86 FIND v(dout1_39) AT=435.025n

* CHECK dout1_40 Vdout1_40ck86 = 0.9 time = 435
.meas tran vdout1_40ck86 FIND v(dout1_40) AT=435.025n

* CHECK dout1_41 Vdout1_41ck86 = 0.9 time = 435
.meas tran vdout1_41ck86 FIND v(dout1_41) AT=435.025n

* CHECK dout1_42 Vdout1_42ck86 = 0.9 time = 435
.meas tran vdout1_42ck86 FIND v(dout1_42) AT=435.025n

* CHECK dout1_43 Vdout1_43ck86 = 0.9 time = 435
.meas tran vdout1_43ck86 FIND v(dout1_43) AT=435.025n

* CHECK dout1_44 Vdout1_44ck86 = 0.9 time = 435
.meas tran vdout1_44ck86 FIND v(dout1_44) AT=435.025n

* CHECK dout1_45 Vdout1_45ck86 = 0.9 time = 435
.meas tran vdout1_45ck86 FIND v(dout1_45) AT=435.025n

* CHECK dout1_46 Vdout1_46ck86 = 0 time = 435
.meas tran vdout1_46ck86 FIND v(dout1_46) AT=435.025n

* CHECK dout1_47 Vdout1_47ck86 = 0.9 time = 435
.meas tran vdout1_47ck86 FIND v(dout1_47) AT=435.025n

* CHECK dout1_48 Vdout1_48ck86 = 0 time = 435
.meas tran vdout1_48ck86 FIND v(dout1_48) AT=435.025n

* CHECK dout1_49 Vdout1_49ck86 = 0.9 time = 435
.meas tran vdout1_49ck86 FIND v(dout1_49) AT=435.025n

* CHECK dout1_50 Vdout1_50ck86 = 0 time = 435
.meas tran vdout1_50ck86 FIND v(dout1_50) AT=435.025n

* CHECK dout1_51 Vdout1_51ck86 = 0 time = 435
.meas tran vdout1_51ck86 FIND v(dout1_51) AT=435.025n

* CHECK dout1_52 Vdout1_52ck86 = 0.9 time = 435
.meas tran vdout1_52ck86 FIND v(dout1_52) AT=435.025n

* CHECK dout1_53 Vdout1_53ck86 = 0.9 time = 435
.meas tran vdout1_53ck86 FIND v(dout1_53) AT=435.025n

* CHECK dout1_54 Vdout1_54ck86 = 0.9 time = 435
.meas tran vdout1_54ck86 FIND v(dout1_54) AT=435.025n

* CHECK dout1_55 Vdout1_55ck86 = 0.9 time = 435
.meas tran vdout1_55ck86 FIND v(dout1_55) AT=435.025n

* CHECK dout1_56 Vdout1_56ck86 = 0.9 time = 435
.meas tran vdout1_56ck86 FIND v(dout1_56) AT=435.025n

* CHECK dout1_57 Vdout1_57ck86 = 0.9 time = 435
.meas tran vdout1_57ck86 FIND v(dout1_57) AT=435.025n

* CHECK dout1_58 Vdout1_58ck86 = 0 time = 435
.meas tran vdout1_58ck86 FIND v(dout1_58) AT=435.025n

* CHECK dout1_59 Vdout1_59ck86 = 0 time = 435
.meas tran vdout1_59ck86 FIND v(dout1_59) AT=435.025n

* CHECK dout1_60 Vdout1_60ck86 = 0.9 time = 435
.meas tran vdout1_60ck86 FIND v(dout1_60) AT=435.025n

* CHECK dout1_61 Vdout1_61ck86 = 0 time = 435
.meas tran vdout1_61ck86 FIND v(dout1_61) AT=435.025n

* CHECK dout1_62 Vdout1_62ck86 = 0 time = 435
.meas tran vdout1_62ck86 FIND v(dout1_62) AT=435.025n

* CHECK dout1_63 Vdout1_63ck86 = 0.9 time = 435
.meas tran vdout1_63ck86 FIND v(dout1_63) AT=435.025n

* CHECK dout1_64 Vdout1_64ck86 = 0.9 time = 435
.meas tran vdout1_64ck86 FIND v(dout1_64) AT=435.025n

* CHECK dout1_65 Vdout1_65ck86 = 0.9 time = 435
.meas tran vdout1_65ck86 FIND v(dout1_65) AT=435.025n

* CHECK dout1_66 Vdout1_66ck86 = 0.9 time = 435
.meas tran vdout1_66ck86 FIND v(dout1_66) AT=435.025n

* CHECK dout1_67 Vdout1_67ck86 = 0 time = 435
.meas tran vdout1_67ck86 FIND v(dout1_67) AT=435.025n

* CHECK dout1_68 Vdout1_68ck86 = 0.9 time = 435
.meas tran vdout1_68ck86 FIND v(dout1_68) AT=435.025n

* CHECK dout1_69 Vdout1_69ck86 = 0 time = 435
.meas tran vdout1_69ck86 FIND v(dout1_69) AT=435.025n

* CHECK dout1_70 Vdout1_70ck86 = 0.9 time = 435
.meas tran vdout1_70ck86 FIND v(dout1_70) AT=435.025n

* CHECK dout1_71 Vdout1_71ck86 = 0.9 time = 435
.meas tran vdout1_71ck86 FIND v(dout1_71) AT=435.025n

* CHECK dout1_72 Vdout1_72ck86 = 0 time = 435
.meas tran vdout1_72ck86 FIND v(dout1_72) AT=435.025n

* CHECK dout1_73 Vdout1_73ck86 = 0.9 time = 435
.meas tran vdout1_73ck86 FIND v(dout1_73) AT=435.025n

* CHECK dout1_74 Vdout1_74ck86 = 0.9 time = 435
.meas tran vdout1_74ck86 FIND v(dout1_74) AT=435.025n

* CHECK dout1_75 Vdout1_75ck86 = 0.9 time = 435
.meas tran vdout1_75ck86 FIND v(dout1_75) AT=435.025n

* CHECK dout1_76 Vdout1_76ck86 = 0 time = 435
.meas tran vdout1_76ck86 FIND v(dout1_76) AT=435.025n

* CHECK dout1_77 Vdout1_77ck86 = 0.9 time = 435
.meas tran vdout1_77ck86 FIND v(dout1_77) AT=435.025n

* CHECK dout1_78 Vdout1_78ck86 = 0.9 time = 435
.meas tran vdout1_78ck86 FIND v(dout1_78) AT=435.025n

* CHECK dout1_79 Vdout1_79ck86 = 0 time = 435
.meas tran vdout1_79ck86 FIND v(dout1_79) AT=435.025n

* CHECK dout1_80 Vdout1_80ck86 = 0 time = 435
.meas tran vdout1_80ck86 FIND v(dout1_80) AT=435.025n

* CHECK dout1_81 Vdout1_81ck86 = 0.9 time = 435
.meas tran vdout1_81ck86 FIND v(dout1_81) AT=435.025n

* CHECK dout1_82 Vdout1_82ck86 = 0.9 time = 435
.meas tran vdout1_82ck86 FIND v(dout1_82) AT=435.025n

* CHECK dout1_83 Vdout1_83ck86 = 0.9 time = 435
.meas tran vdout1_83ck86 FIND v(dout1_83) AT=435.025n

* CHECK dout1_84 Vdout1_84ck86 = 0 time = 435
.meas tran vdout1_84ck86 FIND v(dout1_84) AT=435.025n

* CHECK dout1_85 Vdout1_85ck86 = 0 time = 435
.meas tran vdout1_85ck86 FIND v(dout1_85) AT=435.025n

* CHECK dout1_86 Vdout1_86ck86 = 0.9 time = 435
.meas tran vdout1_86ck86 FIND v(dout1_86) AT=435.025n

* CHECK dout1_87 Vdout1_87ck86 = 0 time = 435
.meas tran vdout1_87ck86 FIND v(dout1_87) AT=435.025n

* CHECK dout1_88 Vdout1_88ck86 = 0 time = 435
.meas tran vdout1_88ck86 FIND v(dout1_88) AT=435.025n

* CHECK dout1_89 Vdout1_89ck86 = 0.9 time = 435
.meas tran vdout1_89ck86 FIND v(dout1_89) AT=435.025n

* CHECK dout1_90 Vdout1_90ck86 = 0.9 time = 435
.meas tran vdout1_90ck86 FIND v(dout1_90) AT=435.025n

* CHECK dout1_91 Vdout1_91ck86 = 0.9 time = 435
.meas tran vdout1_91ck86 FIND v(dout1_91) AT=435.025n

* CHECK dout1_92 Vdout1_92ck86 = 0 time = 435
.meas tran vdout1_92ck86 FIND v(dout1_92) AT=435.025n

* CHECK dout1_93 Vdout1_93ck86 = 0.9 time = 435
.meas tran vdout1_93ck86 FIND v(dout1_93) AT=435.025n

* CHECK dout1_94 Vdout1_94ck86 = 0 time = 435
.meas tran vdout1_94ck86 FIND v(dout1_94) AT=435.025n

* CHECK dout1_95 Vdout1_95ck86 = 0 time = 435
.meas tran vdout1_95ck86 FIND v(dout1_95) AT=435.025n

* CHECK dout1_96 Vdout1_96ck86 = 0.9 time = 435
.meas tran vdout1_96ck86 FIND v(dout1_96) AT=435.025n

* CHECK dout1_97 Vdout1_97ck86 = 0 time = 435
.meas tran vdout1_97ck86 FIND v(dout1_97) AT=435.025n

* CHECK dout1_98 Vdout1_98ck86 = 0 time = 435
.meas tran vdout1_98ck86 FIND v(dout1_98) AT=435.025n

* CHECK dout1_99 Vdout1_99ck86 = 0.9 time = 435
.meas tran vdout1_99ck86 FIND v(dout1_99) AT=435.025n

* CHECK dout1_100 Vdout1_100ck86 = 0.9 time = 435
.meas tran vdout1_100ck86 FIND v(dout1_100) AT=435.025n

* CHECK dout1_101 Vdout1_101ck86 = 0 time = 435
.meas tran vdout1_101ck86 FIND v(dout1_101) AT=435.025n

* CHECK dout1_102 Vdout1_102ck86 = 0.9 time = 435
.meas tran vdout1_102ck86 FIND v(dout1_102) AT=435.025n

* CHECK dout1_103 Vdout1_103ck86 = 0.9 time = 435
.meas tran vdout1_103ck86 FIND v(dout1_103) AT=435.025n

* CHECK dout1_104 Vdout1_104ck86 = 0.9 time = 435
.meas tran vdout1_104ck86 FIND v(dout1_104) AT=435.025n

* CHECK dout1_105 Vdout1_105ck86 = 0.9 time = 435
.meas tran vdout1_105ck86 FIND v(dout1_105) AT=435.025n

* CHECK dout1_106 Vdout1_106ck86 = 0.9 time = 435
.meas tran vdout1_106ck86 FIND v(dout1_106) AT=435.025n

* CHECK dout1_107 Vdout1_107ck86 = 0.9 time = 435
.meas tran vdout1_107ck86 FIND v(dout1_107) AT=435.025n

* CHECK dout1_108 Vdout1_108ck86 = 0 time = 435
.meas tran vdout1_108ck86 FIND v(dout1_108) AT=435.025n

* CHECK dout1_109 Vdout1_109ck86 = 0.9 time = 435
.meas tran vdout1_109ck86 FIND v(dout1_109) AT=435.025n

* CHECK dout1_110 Vdout1_110ck86 = 0 time = 435
.meas tran vdout1_110ck86 FIND v(dout1_110) AT=435.025n

* CHECK dout1_111 Vdout1_111ck86 = 0 time = 435
.meas tran vdout1_111ck86 FIND v(dout1_111) AT=435.025n

* CHECK dout1_112 Vdout1_112ck86 = 0 time = 435
.meas tran vdout1_112ck86 FIND v(dout1_112) AT=435.025n

* CHECK dout1_113 Vdout1_113ck86 = 0 time = 435
.meas tran vdout1_113ck86 FIND v(dout1_113) AT=435.025n

* CHECK dout1_114 Vdout1_114ck86 = 0.9 time = 435
.meas tran vdout1_114ck86 FIND v(dout1_114) AT=435.025n

* CHECK dout1_115 Vdout1_115ck86 = 0.9 time = 435
.meas tran vdout1_115ck86 FIND v(dout1_115) AT=435.025n

* CHECK dout1_116 Vdout1_116ck86 = 0 time = 435
.meas tran vdout1_116ck86 FIND v(dout1_116) AT=435.025n

* CHECK dout1_117 Vdout1_117ck86 = 0 time = 435
.meas tran vdout1_117ck86 FIND v(dout1_117) AT=435.025n

* CHECK dout1_118 Vdout1_118ck86 = 0 time = 435
.meas tran vdout1_118ck86 FIND v(dout1_118) AT=435.025n

* CHECK dout1_119 Vdout1_119ck86 = 0 time = 435
.meas tran vdout1_119ck86 FIND v(dout1_119) AT=435.025n

* CHECK dout1_0 Vdout1_0ck88 = 0.9 time = 445
.meas tran vdout1_0ck88 FIND v(dout1_0) AT=445.025n

* CHECK dout1_1 Vdout1_1ck88 = 0.9 time = 445
.meas tran vdout1_1ck88 FIND v(dout1_1) AT=445.025n

* CHECK dout1_2 Vdout1_2ck88 = 0 time = 445
.meas tran vdout1_2ck88 FIND v(dout1_2) AT=445.025n

* CHECK dout1_3 Vdout1_3ck88 = 0.9 time = 445
.meas tran vdout1_3ck88 FIND v(dout1_3) AT=445.025n

* CHECK dout1_4 Vdout1_4ck88 = 0.9 time = 445
.meas tran vdout1_4ck88 FIND v(dout1_4) AT=445.025n

* CHECK dout1_5 Vdout1_5ck88 = 0.9 time = 445
.meas tran vdout1_5ck88 FIND v(dout1_5) AT=445.025n

* CHECK dout1_6 Vdout1_6ck88 = 0 time = 445
.meas tran vdout1_6ck88 FIND v(dout1_6) AT=445.025n

* CHECK dout1_7 Vdout1_7ck88 = 0 time = 445
.meas tran vdout1_7ck88 FIND v(dout1_7) AT=445.025n

* CHECK dout1_8 Vdout1_8ck88 = 0 time = 445
.meas tran vdout1_8ck88 FIND v(dout1_8) AT=445.025n

* CHECK dout1_9 Vdout1_9ck88 = 0 time = 445
.meas tran vdout1_9ck88 FIND v(dout1_9) AT=445.025n

* CHECK dout1_10 Vdout1_10ck88 = 0.9 time = 445
.meas tran vdout1_10ck88 FIND v(dout1_10) AT=445.025n

* CHECK dout1_11 Vdout1_11ck88 = 0.9 time = 445
.meas tran vdout1_11ck88 FIND v(dout1_11) AT=445.025n

* CHECK dout1_12 Vdout1_12ck88 = 0.9 time = 445
.meas tran vdout1_12ck88 FIND v(dout1_12) AT=445.025n

* CHECK dout1_13 Vdout1_13ck88 = 0.9 time = 445
.meas tran vdout1_13ck88 FIND v(dout1_13) AT=445.025n

* CHECK dout1_14 Vdout1_14ck88 = 0 time = 445
.meas tran vdout1_14ck88 FIND v(dout1_14) AT=445.025n

* CHECK dout1_15 Vdout1_15ck88 = 0 time = 445
.meas tran vdout1_15ck88 FIND v(dout1_15) AT=445.025n

* CHECK dout1_16 Vdout1_16ck88 = 0.9 time = 445
.meas tran vdout1_16ck88 FIND v(dout1_16) AT=445.025n

* CHECK dout1_17 Vdout1_17ck88 = 0 time = 445
.meas tran vdout1_17ck88 FIND v(dout1_17) AT=445.025n

* CHECK dout1_18 Vdout1_18ck88 = 0.9 time = 445
.meas tran vdout1_18ck88 FIND v(dout1_18) AT=445.025n

* CHECK dout1_19 Vdout1_19ck88 = 0.9 time = 445
.meas tran vdout1_19ck88 FIND v(dout1_19) AT=445.025n

* CHECK dout1_20 Vdout1_20ck88 = 0.9 time = 445
.meas tran vdout1_20ck88 FIND v(dout1_20) AT=445.025n

* CHECK dout1_21 Vdout1_21ck88 = 0.9 time = 445
.meas tran vdout1_21ck88 FIND v(dout1_21) AT=445.025n

* CHECK dout1_22 Vdout1_22ck88 = 0.9 time = 445
.meas tran vdout1_22ck88 FIND v(dout1_22) AT=445.025n

* CHECK dout1_23 Vdout1_23ck88 = 0 time = 445
.meas tran vdout1_23ck88 FIND v(dout1_23) AT=445.025n

* CHECK dout1_24 Vdout1_24ck88 = 0 time = 445
.meas tran vdout1_24ck88 FIND v(dout1_24) AT=445.025n

* CHECK dout1_25 Vdout1_25ck88 = 0.9 time = 445
.meas tran vdout1_25ck88 FIND v(dout1_25) AT=445.025n

* CHECK dout1_26 Vdout1_26ck88 = 0.9 time = 445
.meas tran vdout1_26ck88 FIND v(dout1_26) AT=445.025n

* CHECK dout1_27 Vdout1_27ck88 = 0 time = 445
.meas tran vdout1_27ck88 FIND v(dout1_27) AT=445.025n

* CHECK dout1_28 Vdout1_28ck88 = 0.9 time = 445
.meas tran vdout1_28ck88 FIND v(dout1_28) AT=445.025n

* CHECK dout1_29 Vdout1_29ck88 = 0 time = 445
.meas tran vdout1_29ck88 FIND v(dout1_29) AT=445.025n

* CHECK dout1_30 Vdout1_30ck88 = 0 time = 445
.meas tran vdout1_30ck88 FIND v(dout1_30) AT=445.025n

* CHECK dout1_31 Vdout1_31ck88 = 0.9 time = 445
.meas tran vdout1_31ck88 FIND v(dout1_31) AT=445.025n

* CHECK dout1_32 Vdout1_32ck88 = 0 time = 445
.meas tran vdout1_32ck88 FIND v(dout1_32) AT=445.025n

* CHECK dout1_33 Vdout1_33ck88 = 0.9 time = 445
.meas tran vdout1_33ck88 FIND v(dout1_33) AT=445.025n

* CHECK dout1_34 Vdout1_34ck88 = 0 time = 445
.meas tran vdout1_34ck88 FIND v(dout1_34) AT=445.025n

* CHECK dout1_35 Vdout1_35ck88 = 0 time = 445
.meas tran vdout1_35ck88 FIND v(dout1_35) AT=445.025n

* CHECK dout1_36 Vdout1_36ck88 = 0 time = 445
.meas tran vdout1_36ck88 FIND v(dout1_36) AT=445.025n

* CHECK dout1_37 Vdout1_37ck88 = 0 time = 445
.meas tran vdout1_37ck88 FIND v(dout1_37) AT=445.025n

* CHECK dout1_38 Vdout1_38ck88 = 0.9 time = 445
.meas tran vdout1_38ck88 FIND v(dout1_38) AT=445.025n

* CHECK dout1_39 Vdout1_39ck88 = 0 time = 445
.meas tran vdout1_39ck88 FIND v(dout1_39) AT=445.025n

* CHECK dout1_40 Vdout1_40ck88 = 0 time = 445
.meas tran vdout1_40ck88 FIND v(dout1_40) AT=445.025n

* CHECK dout1_41 Vdout1_41ck88 = 0.9 time = 445
.meas tran vdout1_41ck88 FIND v(dout1_41) AT=445.025n

* CHECK dout1_42 Vdout1_42ck88 = 0 time = 445
.meas tran vdout1_42ck88 FIND v(dout1_42) AT=445.025n

* CHECK dout1_43 Vdout1_43ck88 = 0 time = 445
.meas tran vdout1_43ck88 FIND v(dout1_43) AT=445.025n

* CHECK dout1_44 Vdout1_44ck88 = 0 time = 445
.meas tran vdout1_44ck88 FIND v(dout1_44) AT=445.025n

* CHECK dout1_45 Vdout1_45ck88 = 0.9 time = 445
.meas tran vdout1_45ck88 FIND v(dout1_45) AT=445.025n

* CHECK dout1_46 Vdout1_46ck88 = 0 time = 445
.meas tran vdout1_46ck88 FIND v(dout1_46) AT=445.025n

* CHECK dout1_47 Vdout1_47ck88 = 0 time = 445
.meas tran vdout1_47ck88 FIND v(dout1_47) AT=445.025n

* CHECK dout1_48 Vdout1_48ck88 = 0 time = 445
.meas tran vdout1_48ck88 FIND v(dout1_48) AT=445.025n

* CHECK dout1_49 Vdout1_49ck88 = 0 time = 445
.meas tran vdout1_49ck88 FIND v(dout1_49) AT=445.025n

* CHECK dout1_50 Vdout1_50ck88 = 0.9 time = 445
.meas tran vdout1_50ck88 FIND v(dout1_50) AT=445.025n

* CHECK dout1_51 Vdout1_51ck88 = 0.9 time = 445
.meas tran vdout1_51ck88 FIND v(dout1_51) AT=445.025n

* CHECK dout1_52 Vdout1_52ck88 = 0 time = 445
.meas tran vdout1_52ck88 FIND v(dout1_52) AT=445.025n

* CHECK dout1_53 Vdout1_53ck88 = 0.9 time = 445
.meas tran vdout1_53ck88 FIND v(dout1_53) AT=445.025n

* CHECK dout1_54 Vdout1_54ck88 = 0 time = 445
.meas tran vdout1_54ck88 FIND v(dout1_54) AT=445.025n

* CHECK dout1_55 Vdout1_55ck88 = 0 time = 445
.meas tran vdout1_55ck88 FIND v(dout1_55) AT=445.025n

* CHECK dout1_56 Vdout1_56ck88 = 0.9 time = 445
.meas tran vdout1_56ck88 FIND v(dout1_56) AT=445.025n

* CHECK dout1_57 Vdout1_57ck88 = 0.9 time = 445
.meas tran vdout1_57ck88 FIND v(dout1_57) AT=445.025n

* CHECK dout1_58 Vdout1_58ck88 = 0 time = 445
.meas tran vdout1_58ck88 FIND v(dout1_58) AT=445.025n

* CHECK dout1_59 Vdout1_59ck88 = 0.9 time = 445
.meas tran vdout1_59ck88 FIND v(dout1_59) AT=445.025n

* CHECK dout1_60 Vdout1_60ck88 = 0 time = 445
.meas tran vdout1_60ck88 FIND v(dout1_60) AT=445.025n

* CHECK dout1_61 Vdout1_61ck88 = 0 time = 445
.meas tran vdout1_61ck88 FIND v(dout1_61) AT=445.025n

* CHECK dout1_62 Vdout1_62ck88 = 0.9 time = 445
.meas tran vdout1_62ck88 FIND v(dout1_62) AT=445.025n

* CHECK dout1_63 Vdout1_63ck88 = 0 time = 445
.meas tran vdout1_63ck88 FIND v(dout1_63) AT=445.025n

* CHECK dout1_64 Vdout1_64ck88 = 0 time = 445
.meas tran vdout1_64ck88 FIND v(dout1_64) AT=445.025n

* CHECK dout1_65 Vdout1_65ck88 = 0.9 time = 445
.meas tran vdout1_65ck88 FIND v(dout1_65) AT=445.025n

* CHECK dout1_66 Vdout1_66ck88 = 0.9 time = 445
.meas tran vdout1_66ck88 FIND v(dout1_66) AT=445.025n

* CHECK dout1_67 Vdout1_67ck88 = 0.9 time = 445
.meas tran vdout1_67ck88 FIND v(dout1_67) AT=445.025n

* CHECK dout1_68 Vdout1_68ck88 = 0 time = 445
.meas tran vdout1_68ck88 FIND v(dout1_68) AT=445.025n

* CHECK dout1_69 Vdout1_69ck88 = 0.9 time = 445
.meas tran vdout1_69ck88 FIND v(dout1_69) AT=445.025n

* CHECK dout1_70 Vdout1_70ck88 = 0 time = 445
.meas tran vdout1_70ck88 FIND v(dout1_70) AT=445.025n

* CHECK dout1_71 Vdout1_71ck88 = 0.9 time = 445
.meas tran vdout1_71ck88 FIND v(dout1_71) AT=445.025n

* CHECK dout1_72 Vdout1_72ck88 = 0.9 time = 445
.meas tran vdout1_72ck88 FIND v(dout1_72) AT=445.025n

* CHECK dout1_73 Vdout1_73ck88 = 0.9 time = 445
.meas tran vdout1_73ck88 FIND v(dout1_73) AT=445.025n

* CHECK dout1_74 Vdout1_74ck88 = 0.9 time = 445
.meas tran vdout1_74ck88 FIND v(dout1_74) AT=445.025n

* CHECK dout1_75 Vdout1_75ck88 = 0 time = 445
.meas tran vdout1_75ck88 FIND v(dout1_75) AT=445.025n

* CHECK dout1_76 Vdout1_76ck88 = 0 time = 445
.meas tran vdout1_76ck88 FIND v(dout1_76) AT=445.025n

* CHECK dout1_77 Vdout1_77ck88 = 0 time = 445
.meas tran vdout1_77ck88 FIND v(dout1_77) AT=445.025n

* CHECK dout1_78 Vdout1_78ck88 = 0.9 time = 445
.meas tran vdout1_78ck88 FIND v(dout1_78) AT=445.025n

* CHECK dout1_79 Vdout1_79ck88 = 0 time = 445
.meas tran vdout1_79ck88 FIND v(dout1_79) AT=445.025n

* CHECK dout1_80 Vdout1_80ck88 = 0 time = 445
.meas tran vdout1_80ck88 FIND v(dout1_80) AT=445.025n

* CHECK dout1_81 Vdout1_81ck88 = 0 time = 445
.meas tran vdout1_81ck88 FIND v(dout1_81) AT=445.025n

* CHECK dout1_82 Vdout1_82ck88 = 0.9 time = 445
.meas tran vdout1_82ck88 FIND v(dout1_82) AT=445.025n

* CHECK dout1_83 Vdout1_83ck88 = 0 time = 445
.meas tran vdout1_83ck88 FIND v(dout1_83) AT=445.025n

* CHECK dout1_84 Vdout1_84ck88 = 0.9 time = 445
.meas tran vdout1_84ck88 FIND v(dout1_84) AT=445.025n

* CHECK dout1_85 Vdout1_85ck88 = 0.9 time = 445
.meas tran vdout1_85ck88 FIND v(dout1_85) AT=445.025n

* CHECK dout1_86 Vdout1_86ck88 = 0 time = 445
.meas tran vdout1_86ck88 FIND v(dout1_86) AT=445.025n

* CHECK dout1_87 Vdout1_87ck88 = 0 time = 445
.meas tran vdout1_87ck88 FIND v(dout1_87) AT=445.025n

* CHECK dout1_88 Vdout1_88ck88 = 0 time = 445
.meas tran vdout1_88ck88 FIND v(dout1_88) AT=445.025n

* CHECK dout1_89 Vdout1_89ck88 = 0 time = 445
.meas tran vdout1_89ck88 FIND v(dout1_89) AT=445.025n

* CHECK dout1_90 Vdout1_90ck88 = 0 time = 445
.meas tran vdout1_90ck88 FIND v(dout1_90) AT=445.025n

* CHECK dout1_91 Vdout1_91ck88 = 0 time = 445
.meas tran vdout1_91ck88 FIND v(dout1_91) AT=445.025n

* CHECK dout1_92 Vdout1_92ck88 = 0 time = 445
.meas tran vdout1_92ck88 FIND v(dout1_92) AT=445.025n

* CHECK dout1_93 Vdout1_93ck88 = 0.9 time = 445
.meas tran vdout1_93ck88 FIND v(dout1_93) AT=445.025n

* CHECK dout1_94 Vdout1_94ck88 = 0.9 time = 445
.meas tran vdout1_94ck88 FIND v(dout1_94) AT=445.025n

* CHECK dout1_95 Vdout1_95ck88 = 0.9 time = 445
.meas tran vdout1_95ck88 FIND v(dout1_95) AT=445.025n

* CHECK dout1_96 Vdout1_96ck88 = 0 time = 445
.meas tran vdout1_96ck88 FIND v(dout1_96) AT=445.025n

* CHECK dout1_97 Vdout1_97ck88 = 0 time = 445
.meas tran vdout1_97ck88 FIND v(dout1_97) AT=445.025n

* CHECK dout1_98 Vdout1_98ck88 = 0 time = 445
.meas tran vdout1_98ck88 FIND v(dout1_98) AT=445.025n

* CHECK dout1_99 Vdout1_99ck88 = 0 time = 445
.meas tran vdout1_99ck88 FIND v(dout1_99) AT=445.025n

* CHECK dout1_100 Vdout1_100ck88 = 0.9 time = 445
.meas tran vdout1_100ck88 FIND v(dout1_100) AT=445.025n

* CHECK dout1_101 Vdout1_101ck88 = 0 time = 445
.meas tran vdout1_101ck88 FIND v(dout1_101) AT=445.025n

* CHECK dout1_102 Vdout1_102ck88 = 0.9 time = 445
.meas tran vdout1_102ck88 FIND v(dout1_102) AT=445.025n

* CHECK dout1_103 Vdout1_103ck88 = 0 time = 445
.meas tran vdout1_103ck88 FIND v(dout1_103) AT=445.025n

* CHECK dout1_104 Vdout1_104ck88 = 0 time = 445
.meas tran vdout1_104ck88 FIND v(dout1_104) AT=445.025n

* CHECK dout1_105 Vdout1_105ck88 = 0 time = 445
.meas tran vdout1_105ck88 FIND v(dout1_105) AT=445.025n

* CHECK dout1_106 Vdout1_106ck88 = 0.9 time = 445
.meas tran vdout1_106ck88 FIND v(dout1_106) AT=445.025n

* CHECK dout1_107 Vdout1_107ck88 = 0 time = 445
.meas tran vdout1_107ck88 FIND v(dout1_107) AT=445.025n

* CHECK dout1_108 Vdout1_108ck88 = 0.9 time = 445
.meas tran vdout1_108ck88 FIND v(dout1_108) AT=445.025n

* CHECK dout1_109 Vdout1_109ck88 = 0 time = 445
.meas tran vdout1_109ck88 FIND v(dout1_109) AT=445.025n

* CHECK dout1_110 Vdout1_110ck88 = 0 time = 445
.meas tran vdout1_110ck88 FIND v(dout1_110) AT=445.025n

* CHECK dout1_111 Vdout1_111ck88 = 0.9 time = 445
.meas tran vdout1_111ck88 FIND v(dout1_111) AT=445.025n

* CHECK dout1_112 Vdout1_112ck88 = 0 time = 445
.meas tran vdout1_112ck88 FIND v(dout1_112) AT=445.025n

* CHECK dout1_113 Vdout1_113ck88 = 0.9 time = 445
.meas tran vdout1_113ck88 FIND v(dout1_113) AT=445.025n

* CHECK dout1_114 Vdout1_114ck88 = 0.9 time = 445
.meas tran vdout1_114ck88 FIND v(dout1_114) AT=445.025n

* CHECK dout1_115 Vdout1_115ck88 = 0 time = 445
.meas tran vdout1_115ck88 FIND v(dout1_115) AT=445.025n

* CHECK dout1_116 Vdout1_116ck88 = 0.9 time = 445
.meas tran vdout1_116ck88 FIND v(dout1_116) AT=445.025n

* CHECK dout1_117 Vdout1_117ck88 = 0.9 time = 445
.meas tran vdout1_117ck88 FIND v(dout1_117) AT=445.025n

* CHECK dout1_118 Vdout1_118ck88 = 0 time = 445
.meas tran vdout1_118ck88 FIND v(dout1_118) AT=445.025n

* CHECK dout1_119 Vdout1_119ck88 = 0 time = 445
.meas tran vdout1_119ck88 FIND v(dout1_119) AT=445.025n

* CHECK dout1_0 Vdout1_0ck90 = 0.9 time = 455
.meas tran vdout1_0ck90 FIND v(dout1_0) AT=455.025n

* CHECK dout1_1 Vdout1_1ck90 = 0.9 time = 455
.meas tran vdout1_1ck90 FIND v(dout1_1) AT=455.025n

* CHECK dout1_2 Vdout1_2ck90 = 0 time = 455
.meas tran vdout1_2ck90 FIND v(dout1_2) AT=455.025n

* CHECK dout1_3 Vdout1_3ck90 = 0 time = 455
.meas tran vdout1_3ck90 FIND v(dout1_3) AT=455.025n

* CHECK dout1_4 Vdout1_4ck90 = 0.9 time = 455
.meas tran vdout1_4ck90 FIND v(dout1_4) AT=455.025n

* CHECK dout1_5 Vdout1_5ck90 = 0 time = 455
.meas tran vdout1_5ck90 FIND v(dout1_5) AT=455.025n

* CHECK dout1_6 Vdout1_6ck90 = 0.9 time = 455
.meas tran vdout1_6ck90 FIND v(dout1_6) AT=455.025n

* CHECK dout1_7 Vdout1_7ck90 = 0.9 time = 455
.meas tran vdout1_7ck90 FIND v(dout1_7) AT=455.025n

* CHECK dout1_8 Vdout1_8ck90 = 0 time = 455
.meas tran vdout1_8ck90 FIND v(dout1_8) AT=455.025n

* CHECK dout1_9 Vdout1_9ck90 = 0.9 time = 455
.meas tran vdout1_9ck90 FIND v(dout1_9) AT=455.025n

* CHECK dout1_10 Vdout1_10ck90 = 0 time = 455
.meas tran vdout1_10ck90 FIND v(dout1_10) AT=455.025n

* CHECK dout1_11 Vdout1_11ck90 = 0 time = 455
.meas tran vdout1_11ck90 FIND v(dout1_11) AT=455.025n

* CHECK dout1_12 Vdout1_12ck90 = 0 time = 455
.meas tran vdout1_12ck90 FIND v(dout1_12) AT=455.025n

* CHECK dout1_13 Vdout1_13ck90 = 0 time = 455
.meas tran vdout1_13ck90 FIND v(dout1_13) AT=455.025n

* CHECK dout1_14 Vdout1_14ck90 = 0 time = 455
.meas tran vdout1_14ck90 FIND v(dout1_14) AT=455.025n

* CHECK dout1_15 Vdout1_15ck90 = 0 time = 455
.meas tran vdout1_15ck90 FIND v(dout1_15) AT=455.025n

* CHECK dout1_16 Vdout1_16ck90 = 0.9 time = 455
.meas tran vdout1_16ck90 FIND v(dout1_16) AT=455.025n

* CHECK dout1_17 Vdout1_17ck90 = 0.9 time = 455
.meas tran vdout1_17ck90 FIND v(dout1_17) AT=455.025n

* CHECK dout1_18 Vdout1_18ck90 = 0.9 time = 455
.meas tran vdout1_18ck90 FIND v(dout1_18) AT=455.025n

* CHECK dout1_19 Vdout1_19ck90 = 0.9 time = 455
.meas tran vdout1_19ck90 FIND v(dout1_19) AT=455.025n

* CHECK dout1_20 Vdout1_20ck90 = 0.9 time = 455
.meas tran vdout1_20ck90 FIND v(dout1_20) AT=455.025n

* CHECK dout1_21 Vdout1_21ck90 = 0 time = 455
.meas tran vdout1_21ck90 FIND v(dout1_21) AT=455.025n

* CHECK dout1_22 Vdout1_22ck90 = 0.9 time = 455
.meas tran vdout1_22ck90 FIND v(dout1_22) AT=455.025n

* CHECK dout1_23 Vdout1_23ck90 = 0.9 time = 455
.meas tran vdout1_23ck90 FIND v(dout1_23) AT=455.025n

* CHECK dout1_24 Vdout1_24ck90 = 0 time = 455
.meas tran vdout1_24ck90 FIND v(dout1_24) AT=455.025n

* CHECK dout1_25 Vdout1_25ck90 = 0.9 time = 455
.meas tran vdout1_25ck90 FIND v(dout1_25) AT=455.025n

* CHECK dout1_26 Vdout1_26ck90 = 0.9 time = 455
.meas tran vdout1_26ck90 FIND v(dout1_26) AT=455.025n

* CHECK dout1_27 Vdout1_27ck90 = 0 time = 455
.meas tran vdout1_27ck90 FIND v(dout1_27) AT=455.025n

* CHECK dout1_28 Vdout1_28ck90 = 0.9 time = 455
.meas tran vdout1_28ck90 FIND v(dout1_28) AT=455.025n

* CHECK dout1_29 Vdout1_29ck90 = 0 time = 455
.meas tran vdout1_29ck90 FIND v(dout1_29) AT=455.025n

* CHECK dout1_30 Vdout1_30ck90 = 0 time = 455
.meas tran vdout1_30ck90 FIND v(dout1_30) AT=455.025n

* CHECK dout1_31 Vdout1_31ck90 = 0.9 time = 455
.meas tran vdout1_31ck90 FIND v(dout1_31) AT=455.025n

* CHECK dout1_32 Vdout1_32ck90 = 0 time = 455
.meas tran vdout1_32ck90 FIND v(dout1_32) AT=455.025n

* CHECK dout1_33 Vdout1_33ck90 = 0.9 time = 455
.meas tran vdout1_33ck90 FIND v(dout1_33) AT=455.025n

* CHECK dout1_34 Vdout1_34ck90 = 0 time = 455
.meas tran vdout1_34ck90 FIND v(dout1_34) AT=455.025n

* CHECK dout1_35 Vdout1_35ck90 = 0 time = 455
.meas tran vdout1_35ck90 FIND v(dout1_35) AT=455.025n

* CHECK dout1_36 Vdout1_36ck90 = 0 time = 455
.meas tran vdout1_36ck90 FIND v(dout1_36) AT=455.025n

* CHECK dout1_37 Vdout1_37ck90 = 0 time = 455
.meas tran vdout1_37ck90 FIND v(dout1_37) AT=455.025n

* CHECK dout1_38 Vdout1_38ck90 = 0.9 time = 455
.meas tran vdout1_38ck90 FIND v(dout1_38) AT=455.025n

* CHECK dout1_39 Vdout1_39ck90 = 0 time = 455
.meas tran vdout1_39ck90 FIND v(dout1_39) AT=455.025n

* CHECK dout1_40 Vdout1_40ck90 = 0 time = 455
.meas tran vdout1_40ck90 FIND v(dout1_40) AT=455.025n

* CHECK dout1_41 Vdout1_41ck90 = 0.9 time = 455
.meas tran vdout1_41ck90 FIND v(dout1_41) AT=455.025n

* CHECK dout1_42 Vdout1_42ck90 = 0 time = 455
.meas tran vdout1_42ck90 FIND v(dout1_42) AT=455.025n

* CHECK dout1_43 Vdout1_43ck90 = 0 time = 455
.meas tran vdout1_43ck90 FIND v(dout1_43) AT=455.025n

* CHECK dout1_44 Vdout1_44ck90 = 0 time = 455
.meas tran vdout1_44ck90 FIND v(dout1_44) AT=455.025n

* CHECK dout1_45 Vdout1_45ck90 = 0.9 time = 455
.meas tran vdout1_45ck90 FIND v(dout1_45) AT=455.025n

* CHECK dout1_46 Vdout1_46ck90 = 0 time = 455
.meas tran vdout1_46ck90 FIND v(dout1_46) AT=455.025n

* CHECK dout1_47 Vdout1_47ck90 = 0 time = 455
.meas tran vdout1_47ck90 FIND v(dout1_47) AT=455.025n

* CHECK dout1_48 Vdout1_48ck90 = 0 time = 455
.meas tran vdout1_48ck90 FIND v(dout1_48) AT=455.025n

* CHECK dout1_49 Vdout1_49ck90 = 0 time = 455
.meas tran vdout1_49ck90 FIND v(dout1_49) AT=455.025n

* CHECK dout1_50 Vdout1_50ck90 = 0.9 time = 455
.meas tran vdout1_50ck90 FIND v(dout1_50) AT=455.025n

* CHECK dout1_51 Vdout1_51ck90 = 0.9 time = 455
.meas tran vdout1_51ck90 FIND v(dout1_51) AT=455.025n

* CHECK dout1_52 Vdout1_52ck90 = 0 time = 455
.meas tran vdout1_52ck90 FIND v(dout1_52) AT=455.025n

* CHECK dout1_53 Vdout1_53ck90 = 0.9 time = 455
.meas tran vdout1_53ck90 FIND v(dout1_53) AT=455.025n

* CHECK dout1_54 Vdout1_54ck90 = 0 time = 455
.meas tran vdout1_54ck90 FIND v(dout1_54) AT=455.025n

* CHECK dout1_55 Vdout1_55ck90 = 0 time = 455
.meas tran vdout1_55ck90 FIND v(dout1_55) AT=455.025n

* CHECK dout1_56 Vdout1_56ck90 = 0.9 time = 455
.meas tran vdout1_56ck90 FIND v(dout1_56) AT=455.025n

* CHECK dout1_57 Vdout1_57ck90 = 0.9 time = 455
.meas tran vdout1_57ck90 FIND v(dout1_57) AT=455.025n

* CHECK dout1_58 Vdout1_58ck90 = 0 time = 455
.meas tran vdout1_58ck90 FIND v(dout1_58) AT=455.025n

* CHECK dout1_59 Vdout1_59ck90 = 0.9 time = 455
.meas tran vdout1_59ck90 FIND v(dout1_59) AT=455.025n

* CHECK dout1_60 Vdout1_60ck90 = 0.9 time = 455
.meas tran vdout1_60ck90 FIND v(dout1_60) AT=455.025n

* CHECK dout1_61 Vdout1_61ck90 = 0.9 time = 455
.meas tran vdout1_61ck90 FIND v(dout1_61) AT=455.025n

* CHECK dout1_62 Vdout1_62ck90 = 0.9 time = 455
.meas tran vdout1_62ck90 FIND v(dout1_62) AT=455.025n

* CHECK dout1_63 Vdout1_63ck90 = 0 time = 455
.meas tran vdout1_63ck90 FIND v(dout1_63) AT=455.025n

* CHECK dout1_64 Vdout1_64ck90 = 0.9 time = 455
.meas tran vdout1_64ck90 FIND v(dout1_64) AT=455.025n

* CHECK dout1_65 Vdout1_65ck90 = 0.9 time = 455
.meas tran vdout1_65ck90 FIND v(dout1_65) AT=455.025n

* CHECK dout1_66 Vdout1_66ck90 = 0.9 time = 455
.meas tran vdout1_66ck90 FIND v(dout1_66) AT=455.025n

* CHECK dout1_67 Vdout1_67ck90 = 0 time = 455
.meas tran vdout1_67ck90 FIND v(dout1_67) AT=455.025n

* CHECK dout1_68 Vdout1_68ck90 = 0.9 time = 455
.meas tran vdout1_68ck90 FIND v(dout1_68) AT=455.025n

* CHECK dout1_69 Vdout1_69ck90 = 0.9 time = 455
.meas tran vdout1_69ck90 FIND v(dout1_69) AT=455.025n

* CHECK dout1_70 Vdout1_70ck90 = 0 time = 455
.meas tran vdout1_70ck90 FIND v(dout1_70) AT=455.025n

* CHECK dout1_71 Vdout1_71ck90 = 0 time = 455
.meas tran vdout1_71ck90 FIND v(dout1_71) AT=455.025n

* CHECK dout1_72 Vdout1_72ck90 = 0.9 time = 455
.meas tran vdout1_72ck90 FIND v(dout1_72) AT=455.025n

* CHECK dout1_73 Vdout1_73ck90 = 0 time = 455
.meas tran vdout1_73ck90 FIND v(dout1_73) AT=455.025n

* CHECK dout1_74 Vdout1_74ck90 = 0 time = 455
.meas tran vdout1_74ck90 FIND v(dout1_74) AT=455.025n

* CHECK dout1_75 Vdout1_75ck90 = 0.9 time = 455
.meas tran vdout1_75ck90 FIND v(dout1_75) AT=455.025n

* CHECK dout1_76 Vdout1_76ck90 = 0.9 time = 455
.meas tran vdout1_76ck90 FIND v(dout1_76) AT=455.025n

* CHECK dout1_77 Vdout1_77ck90 = 0.9 time = 455
.meas tran vdout1_77ck90 FIND v(dout1_77) AT=455.025n

* CHECK dout1_78 Vdout1_78ck90 = 0.9 time = 455
.meas tran vdout1_78ck90 FIND v(dout1_78) AT=455.025n

* CHECK dout1_79 Vdout1_79ck90 = 0.9 time = 455
.meas tran vdout1_79ck90 FIND v(dout1_79) AT=455.025n

* CHECK dout1_80 Vdout1_80ck90 = 0.9 time = 455
.meas tran vdout1_80ck90 FIND v(dout1_80) AT=455.025n

* CHECK dout1_81 Vdout1_81ck90 = 0.9 time = 455
.meas tran vdout1_81ck90 FIND v(dout1_81) AT=455.025n

* CHECK dout1_82 Vdout1_82ck90 = 0 time = 455
.meas tran vdout1_82ck90 FIND v(dout1_82) AT=455.025n

* CHECK dout1_83 Vdout1_83ck90 = 0 time = 455
.meas tran vdout1_83ck90 FIND v(dout1_83) AT=455.025n

* CHECK dout1_84 Vdout1_84ck90 = 0 time = 455
.meas tran vdout1_84ck90 FIND v(dout1_84) AT=455.025n

* CHECK dout1_85 Vdout1_85ck90 = 0 time = 455
.meas tran vdout1_85ck90 FIND v(dout1_85) AT=455.025n

* CHECK dout1_86 Vdout1_86ck90 = 0 time = 455
.meas tran vdout1_86ck90 FIND v(dout1_86) AT=455.025n

* CHECK dout1_87 Vdout1_87ck90 = 0.9 time = 455
.meas tran vdout1_87ck90 FIND v(dout1_87) AT=455.025n

* CHECK dout1_88 Vdout1_88ck90 = 0.9 time = 455
.meas tran vdout1_88ck90 FIND v(dout1_88) AT=455.025n

* CHECK dout1_89 Vdout1_89ck90 = 0.9 time = 455
.meas tran vdout1_89ck90 FIND v(dout1_89) AT=455.025n

* CHECK dout1_90 Vdout1_90ck90 = 0 time = 455
.meas tran vdout1_90ck90 FIND v(dout1_90) AT=455.025n

* CHECK dout1_91 Vdout1_91ck90 = 0 time = 455
.meas tran vdout1_91ck90 FIND v(dout1_91) AT=455.025n

* CHECK dout1_92 Vdout1_92ck90 = 0 time = 455
.meas tran vdout1_92ck90 FIND v(dout1_92) AT=455.025n

* CHECK dout1_93 Vdout1_93ck90 = 0.9 time = 455
.meas tran vdout1_93ck90 FIND v(dout1_93) AT=455.025n

* CHECK dout1_94 Vdout1_94ck90 = 0.9 time = 455
.meas tran vdout1_94ck90 FIND v(dout1_94) AT=455.025n

* CHECK dout1_95 Vdout1_95ck90 = 0.9 time = 455
.meas tran vdout1_95ck90 FIND v(dout1_95) AT=455.025n

* CHECK dout1_96 Vdout1_96ck90 = 0 time = 455
.meas tran vdout1_96ck90 FIND v(dout1_96) AT=455.025n

* CHECK dout1_97 Vdout1_97ck90 = 0 time = 455
.meas tran vdout1_97ck90 FIND v(dout1_97) AT=455.025n

* CHECK dout1_98 Vdout1_98ck90 = 0 time = 455
.meas tran vdout1_98ck90 FIND v(dout1_98) AT=455.025n

* CHECK dout1_99 Vdout1_99ck90 = 0 time = 455
.meas tran vdout1_99ck90 FIND v(dout1_99) AT=455.025n

* CHECK dout1_100 Vdout1_100ck90 = 0.9 time = 455
.meas tran vdout1_100ck90 FIND v(dout1_100) AT=455.025n

* CHECK dout1_101 Vdout1_101ck90 = 0 time = 455
.meas tran vdout1_101ck90 FIND v(dout1_101) AT=455.025n

* CHECK dout1_102 Vdout1_102ck90 = 0.9 time = 455
.meas tran vdout1_102ck90 FIND v(dout1_102) AT=455.025n

* CHECK dout1_103 Vdout1_103ck90 = 0 time = 455
.meas tran vdout1_103ck90 FIND v(dout1_103) AT=455.025n

* CHECK dout1_104 Vdout1_104ck90 = 0 time = 455
.meas tran vdout1_104ck90 FIND v(dout1_104) AT=455.025n

* CHECK dout1_105 Vdout1_105ck90 = 0 time = 455
.meas tran vdout1_105ck90 FIND v(dout1_105) AT=455.025n

* CHECK dout1_106 Vdout1_106ck90 = 0.9 time = 455
.meas tran vdout1_106ck90 FIND v(dout1_106) AT=455.025n

* CHECK dout1_107 Vdout1_107ck90 = 0 time = 455
.meas tran vdout1_107ck90 FIND v(dout1_107) AT=455.025n

* CHECK dout1_108 Vdout1_108ck90 = 0.9 time = 455
.meas tran vdout1_108ck90 FIND v(dout1_108) AT=455.025n

* CHECK dout1_109 Vdout1_109ck90 = 0 time = 455
.meas tran vdout1_109ck90 FIND v(dout1_109) AT=455.025n

* CHECK dout1_110 Vdout1_110ck90 = 0 time = 455
.meas tran vdout1_110ck90 FIND v(dout1_110) AT=455.025n

* CHECK dout1_111 Vdout1_111ck90 = 0.9 time = 455
.meas tran vdout1_111ck90 FIND v(dout1_111) AT=455.025n

* CHECK dout1_112 Vdout1_112ck90 = 0 time = 455
.meas tran vdout1_112ck90 FIND v(dout1_112) AT=455.025n

* CHECK dout1_113 Vdout1_113ck90 = 0.9 time = 455
.meas tran vdout1_113ck90 FIND v(dout1_113) AT=455.025n

* CHECK dout1_114 Vdout1_114ck90 = 0.9 time = 455
.meas tran vdout1_114ck90 FIND v(dout1_114) AT=455.025n

* CHECK dout1_115 Vdout1_115ck90 = 0 time = 455
.meas tran vdout1_115ck90 FIND v(dout1_115) AT=455.025n

* CHECK dout1_116 Vdout1_116ck90 = 0.9 time = 455
.meas tran vdout1_116ck90 FIND v(dout1_116) AT=455.025n

* CHECK dout1_117 Vdout1_117ck90 = 0.9 time = 455
.meas tran vdout1_117ck90 FIND v(dout1_117) AT=455.025n

* CHECK dout1_118 Vdout1_118ck90 = 0 time = 455
.meas tran vdout1_118ck90 FIND v(dout1_118) AT=455.025n

* CHECK dout1_119 Vdout1_119ck90 = 0 time = 455
.meas tran vdout1_119ck90 FIND v(dout1_119) AT=455.025n

* CHECK dout1_0 Vdout1_0ck101 = 0 time = 510
.meas tran vdout1_0ck101 FIND v(dout1_0) AT=510.025n

* CHECK dout1_1 Vdout1_1ck101 = 0 time = 510
.meas tran vdout1_1ck101 FIND v(dout1_1) AT=510.025n

* CHECK dout1_2 Vdout1_2ck101 = 0 time = 510
.meas tran vdout1_2ck101 FIND v(dout1_2) AT=510.025n

* CHECK dout1_3 Vdout1_3ck101 = 0.9 time = 510
.meas tran vdout1_3ck101 FIND v(dout1_3) AT=510.025n

* CHECK dout1_4 Vdout1_4ck101 = 0.9 time = 510
.meas tran vdout1_4ck101 FIND v(dout1_4) AT=510.025n

* CHECK dout1_5 Vdout1_5ck101 = 0 time = 510
.meas tran vdout1_5ck101 FIND v(dout1_5) AT=510.025n

* CHECK dout1_6 Vdout1_6ck101 = 0 time = 510
.meas tran vdout1_6ck101 FIND v(dout1_6) AT=510.025n

* CHECK dout1_7 Vdout1_7ck101 = 0 time = 510
.meas tran vdout1_7ck101 FIND v(dout1_7) AT=510.025n

* CHECK dout1_8 Vdout1_8ck101 = 0 time = 510
.meas tran vdout1_8ck101 FIND v(dout1_8) AT=510.025n

* CHECK dout1_9 Vdout1_9ck101 = 0.9 time = 510
.meas tran vdout1_9ck101 FIND v(dout1_9) AT=510.025n

* CHECK dout1_10 Vdout1_10ck101 = 0 time = 510
.meas tran vdout1_10ck101 FIND v(dout1_10) AT=510.025n

* CHECK dout1_11 Vdout1_11ck101 = 0.9 time = 510
.meas tran vdout1_11ck101 FIND v(dout1_11) AT=510.025n

* CHECK dout1_12 Vdout1_12ck101 = 0 time = 510
.meas tran vdout1_12ck101 FIND v(dout1_12) AT=510.025n

* CHECK dout1_13 Vdout1_13ck101 = 0 time = 510
.meas tran vdout1_13ck101 FIND v(dout1_13) AT=510.025n

* CHECK dout1_14 Vdout1_14ck101 = 0.9 time = 510
.meas tran vdout1_14ck101 FIND v(dout1_14) AT=510.025n

* CHECK dout1_15 Vdout1_15ck101 = 0 time = 510
.meas tran vdout1_15ck101 FIND v(dout1_15) AT=510.025n

* CHECK dout1_16 Vdout1_16ck101 = 0 time = 510
.meas tran vdout1_16ck101 FIND v(dout1_16) AT=510.025n

* CHECK dout1_17 Vdout1_17ck101 = 0.9 time = 510
.meas tran vdout1_17ck101 FIND v(dout1_17) AT=510.025n

* CHECK dout1_18 Vdout1_18ck101 = 0 time = 510
.meas tran vdout1_18ck101 FIND v(dout1_18) AT=510.025n

* CHECK dout1_19 Vdout1_19ck101 = 0 time = 510
.meas tran vdout1_19ck101 FIND v(dout1_19) AT=510.025n

* CHECK dout1_20 Vdout1_20ck101 = 0 time = 510
.meas tran vdout1_20ck101 FIND v(dout1_20) AT=510.025n

* CHECK dout1_21 Vdout1_21ck101 = 0 time = 510
.meas tran vdout1_21ck101 FIND v(dout1_21) AT=510.025n

* CHECK dout1_22 Vdout1_22ck101 = 0 time = 510
.meas tran vdout1_22ck101 FIND v(dout1_22) AT=510.025n

* CHECK dout1_23 Vdout1_23ck101 = 0.9 time = 510
.meas tran vdout1_23ck101 FIND v(dout1_23) AT=510.025n

* CHECK dout1_24 Vdout1_24ck101 = 0 time = 510
.meas tran vdout1_24ck101 FIND v(dout1_24) AT=510.025n

* CHECK dout1_25 Vdout1_25ck101 = 0.9 time = 510
.meas tran vdout1_25ck101 FIND v(dout1_25) AT=510.025n

* CHECK dout1_26 Vdout1_26ck101 = 0 time = 510
.meas tran vdout1_26ck101 FIND v(dout1_26) AT=510.025n

* CHECK dout1_27 Vdout1_27ck101 = 0 time = 510
.meas tran vdout1_27ck101 FIND v(dout1_27) AT=510.025n

* CHECK dout1_28 Vdout1_28ck101 = 0.9 time = 510
.meas tran vdout1_28ck101 FIND v(dout1_28) AT=510.025n

* CHECK dout1_29 Vdout1_29ck101 = 0.9 time = 510
.meas tran vdout1_29ck101 FIND v(dout1_29) AT=510.025n

* CHECK dout1_30 Vdout1_30ck101 = 0.9 time = 510
.meas tran vdout1_30ck101 FIND v(dout1_30) AT=510.025n

* CHECK dout1_31 Vdout1_31ck101 = 0.9 time = 510
.meas tran vdout1_31ck101 FIND v(dout1_31) AT=510.025n

* CHECK dout1_32 Vdout1_32ck101 = 0.9 time = 510
.meas tran vdout1_32ck101 FIND v(dout1_32) AT=510.025n

* CHECK dout1_33 Vdout1_33ck101 = 0 time = 510
.meas tran vdout1_33ck101 FIND v(dout1_33) AT=510.025n

* CHECK dout1_34 Vdout1_34ck101 = 0.9 time = 510
.meas tran vdout1_34ck101 FIND v(dout1_34) AT=510.025n

* CHECK dout1_35 Vdout1_35ck101 = 0 time = 510
.meas tran vdout1_35ck101 FIND v(dout1_35) AT=510.025n

* CHECK dout1_36 Vdout1_36ck101 = 0.9 time = 510
.meas tran vdout1_36ck101 FIND v(dout1_36) AT=510.025n

* CHECK dout1_37 Vdout1_37ck101 = 0.9 time = 510
.meas tran vdout1_37ck101 FIND v(dout1_37) AT=510.025n

* CHECK dout1_38 Vdout1_38ck101 = 0 time = 510
.meas tran vdout1_38ck101 FIND v(dout1_38) AT=510.025n

* CHECK dout1_39 Vdout1_39ck101 = 0 time = 510
.meas tran vdout1_39ck101 FIND v(dout1_39) AT=510.025n

* CHECK dout1_40 Vdout1_40ck101 = 0.9 time = 510
.meas tran vdout1_40ck101 FIND v(dout1_40) AT=510.025n

* CHECK dout1_41 Vdout1_41ck101 = 0.9 time = 510
.meas tran vdout1_41ck101 FIND v(dout1_41) AT=510.025n

* CHECK dout1_42 Vdout1_42ck101 = 0 time = 510
.meas tran vdout1_42ck101 FIND v(dout1_42) AT=510.025n

* CHECK dout1_43 Vdout1_43ck101 = 0 time = 510
.meas tran vdout1_43ck101 FIND v(dout1_43) AT=510.025n

* CHECK dout1_44 Vdout1_44ck101 = 0 time = 510
.meas tran vdout1_44ck101 FIND v(dout1_44) AT=510.025n

* CHECK dout1_45 Vdout1_45ck101 = 0 time = 510
.meas tran vdout1_45ck101 FIND v(dout1_45) AT=510.025n

* CHECK dout1_46 Vdout1_46ck101 = 0 time = 510
.meas tran vdout1_46ck101 FIND v(dout1_46) AT=510.025n

* CHECK dout1_47 Vdout1_47ck101 = 0 time = 510
.meas tran vdout1_47ck101 FIND v(dout1_47) AT=510.025n

* CHECK dout1_48 Vdout1_48ck101 = 0 time = 510
.meas tran vdout1_48ck101 FIND v(dout1_48) AT=510.025n

* CHECK dout1_49 Vdout1_49ck101 = 0.9 time = 510
.meas tran vdout1_49ck101 FIND v(dout1_49) AT=510.025n

* CHECK dout1_50 Vdout1_50ck101 = 0 time = 510
.meas tran vdout1_50ck101 FIND v(dout1_50) AT=510.025n

* CHECK dout1_51 Vdout1_51ck101 = 0.9 time = 510
.meas tran vdout1_51ck101 FIND v(dout1_51) AT=510.025n

* CHECK dout1_52 Vdout1_52ck101 = 0.9 time = 510
.meas tran vdout1_52ck101 FIND v(dout1_52) AT=510.025n

* CHECK dout1_53 Vdout1_53ck101 = 0.9 time = 510
.meas tran vdout1_53ck101 FIND v(dout1_53) AT=510.025n

* CHECK dout1_54 Vdout1_54ck101 = 0.9 time = 510
.meas tran vdout1_54ck101 FIND v(dout1_54) AT=510.025n

* CHECK dout1_55 Vdout1_55ck101 = 0 time = 510
.meas tran vdout1_55ck101 FIND v(dout1_55) AT=510.025n

* CHECK dout1_56 Vdout1_56ck101 = 0.9 time = 510
.meas tran vdout1_56ck101 FIND v(dout1_56) AT=510.025n

* CHECK dout1_57 Vdout1_57ck101 = 0.9 time = 510
.meas tran vdout1_57ck101 FIND v(dout1_57) AT=510.025n

* CHECK dout1_58 Vdout1_58ck101 = 0 time = 510
.meas tran vdout1_58ck101 FIND v(dout1_58) AT=510.025n

* CHECK dout1_59 Vdout1_59ck101 = 0.9 time = 510
.meas tran vdout1_59ck101 FIND v(dout1_59) AT=510.025n

* CHECK dout1_60 Vdout1_60ck101 = 0 time = 510
.meas tran vdout1_60ck101 FIND v(dout1_60) AT=510.025n

* CHECK dout1_61 Vdout1_61ck101 = 0.9 time = 510
.meas tran vdout1_61ck101 FIND v(dout1_61) AT=510.025n

* CHECK dout1_62 Vdout1_62ck101 = 0 time = 510
.meas tran vdout1_62ck101 FIND v(dout1_62) AT=510.025n

* CHECK dout1_63 Vdout1_63ck101 = 0.9 time = 510
.meas tran vdout1_63ck101 FIND v(dout1_63) AT=510.025n

* CHECK dout1_64 Vdout1_64ck101 = 0.9 time = 510
.meas tran vdout1_64ck101 FIND v(dout1_64) AT=510.025n

* CHECK dout1_65 Vdout1_65ck101 = 0.9 time = 510
.meas tran vdout1_65ck101 FIND v(dout1_65) AT=510.025n

* CHECK dout1_66 Vdout1_66ck101 = 0.9 time = 510
.meas tran vdout1_66ck101 FIND v(dout1_66) AT=510.025n

* CHECK dout1_67 Vdout1_67ck101 = 0.9 time = 510
.meas tran vdout1_67ck101 FIND v(dout1_67) AT=510.025n

* CHECK dout1_68 Vdout1_68ck101 = 0.9 time = 510
.meas tran vdout1_68ck101 FIND v(dout1_68) AT=510.025n

* CHECK dout1_69 Vdout1_69ck101 = 0 time = 510
.meas tran vdout1_69ck101 FIND v(dout1_69) AT=510.025n

* CHECK dout1_70 Vdout1_70ck101 = 0.9 time = 510
.meas tran vdout1_70ck101 FIND v(dout1_70) AT=510.025n

* CHECK dout1_71 Vdout1_71ck101 = 0.9 time = 510
.meas tran vdout1_71ck101 FIND v(dout1_71) AT=510.025n

* CHECK dout1_72 Vdout1_72ck101 = 0.9 time = 510
.meas tran vdout1_72ck101 FIND v(dout1_72) AT=510.025n

* CHECK dout1_73 Vdout1_73ck101 = 0 time = 510
.meas tran vdout1_73ck101 FIND v(dout1_73) AT=510.025n

* CHECK dout1_74 Vdout1_74ck101 = 0 time = 510
.meas tran vdout1_74ck101 FIND v(dout1_74) AT=510.025n

* CHECK dout1_75 Vdout1_75ck101 = 0.9 time = 510
.meas tran vdout1_75ck101 FIND v(dout1_75) AT=510.025n

* CHECK dout1_76 Vdout1_76ck101 = 0 time = 510
.meas tran vdout1_76ck101 FIND v(dout1_76) AT=510.025n

* CHECK dout1_77 Vdout1_77ck101 = 0.9 time = 510
.meas tran vdout1_77ck101 FIND v(dout1_77) AT=510.025n

* CHECK dout1_78 Vdout1_78ck101 = 0.9 time = 510
.meas tran vdout1_78ck101 FIND v(dout1_78) AT=510.025n

* CHECK dout1_79 Vdout1_79ck101 = 0 time = 510
.meas tran vdout1_79ck101 FIND v(dout1_79) AT=510.025n

* CHECK dout1_80 Vdout1_80ck101 = 0 time = 510
.meas tran vdout1_80ck101 FIND v(dout1_80) AT=510.025n

* CHECK dout1_81 Vdout1_81ck101 = 0 time = 510
.meas tran vdout1_81ck101 FIND v(dout1_81) AT=510.025n

* CHECK dout1_82 Vdout1_82ck101 = 0 time = 510
.meas tran vdout1_82ck101 FIND v(dout1_82) AT=510.025n

* CHECK dout1_83 Vdout1_83ck101 = 0 time = 510
.meas tran vdout1_83ck101 FIND v(dout1_83) AT=510.025n

* CHECK dout1_84 Vdout1_84ck101 = 0 time = 510
.meas tran vdout1_84ck101 FIND v(dout1_84) AT=510.025n

* CHECK dout1_85 Vdout1_85ck101 = 0.9 time = 510
.meas tran vdout1_85ck101 FIND v(dout1_85) AT=510.025n

* CHECK dout1_86 Vdout1_86ck101 = 0.9 time = 510
.meas tran vdout1_86ck101 FIND v(dout1_86) AT=510.025n

* CHECK dout1_87 Vdout1_87ck101 = 0.9 time = 510
.meas tran vdout1_87ck101 FIND v(dout1_87) AT=510.025n

* CHECK dout1_88 Vdout1_88ck101 = 0 time = 510
.meas tran vdout1_88ck101 FIND v(dout1_88) AT=510.025n

* CHECK dout1_89 Vdout1_89ck101 = 0 time = 510
.meas tran vdout1_89ck101 FIND v(dout1_89) AT=510.025n

* CHECK dout1_90 Vdout1_90ck101 = 0.9 time = 510
.meas tran vdout1_90ck101 FIND v(dout1_90) AT=510.025n

* CHECK dout1_91 Vdout1_91ck101 = 0.9 time = 510
.meas tran vdout1_91ck101 FIND v(dout1_91) AT=510.025n

* CHECK dout1_92 Vdout1_92ck101 = 0 time = 510
.meas tran vdout1_92ck101 FIND v(dout1_92) AT=510.025n

* CHECK dout1_93 Vdout1_93ck101 = 0.9 time = 510
.meas tran vdout1_93ck101 FIND v(dout1_93) AT=510.025n

* CHECK dout1_94 Vdout1_94ck101 = 0.9 time = 510
.meas tran vdout1_94ck101 FIND v(dout1_94) AT=510.025n

* CHECK dout1_95 Vdout1_95ck101 = 0.9 time = 510
.meas tran vdout1_95ck101 FIND v(dout1_95) AT=510.025n

* CHECK dout1_96 Vdout1_96ck101 = 0 time = 510
.meas tran vdout1_96ck101 FIND v(dout1_96) AT=510.025n

* CHECK dout1_97 Vdout1_97ck101 = 0 time = 510
.meas tran vdout1_97ck101 FIND v(dout1_97) AT=510.025n

* CHECK dout1_98 Vdout1_98ck101 = 0 time = 510
.meas tran vdout1_98ck101 FIND v(dout1_98) AT=510.025n

* CHECK dout1_99 Vdout1_99ck101 = 0.9 time = 510
.meas tran vdout1_99ck101 FIND v(dout1_99) AT=510.025n

* CHECK dout1_100 Vdout1_100ck101 = 0 time = 510
.meas tran vdout1_100ck101 FIND v(dout1_100) AT=510.025n

* CHECK dout1_101 Vdout1_101ck101 = 0.9 time = 510
.meas tran vdout1_101ck101 FIND v(dout1_101) AT=510.025n

* CHECK dout1_102 Vdout1_102ck101 = 0.9 time = 510
.meas tran vdout1_102ck101 FIND v(dout1_102) AT=510.025n

* CHECK dout1_103 Vdout1_103ck101 = 0 time = 510
.meas tran vdout1_103ck101 FIND v(dout1_103) AT=510.025n

* CHECK dout1_104 Vdout1_104ck101 = 0 time = 510
.meas tran vdout1_104ck101 FIND v(dout1_104) AT=510.025n

* CHECK dout1_105 Vdout1_105ck101 = 0 time = 510
.meas tran vdout1_105ck101 FIND v(dout1_105) AT=510.025n

* CHECK dout1_106 Vdout1_106ck101 = 0 time = 510
.meas tran vdout1_106ck101 FIND v(dout1_106) AT=510.025n

* CHECK dout1_107 Vdout1_107ck101 = 0 time = 510
.meas tran vdout1_107ck101 FIND v(dout1_107) AT=510.025n

* CHECK dout1_108 Vdout1_108ck101 = 0 time = 510
.meas tran vdout1_108ck101 FIND v(dout1_108) AT=510.025n

* CHECK dout1_109 Vdout1_109ck101 = 0.9 time = 510
.meas tran vdout1_109ck101 FIND v(dout1_109) AT=510.025n

* CHECK dout1_110 Vdout1_110ck101 = 0 time = 510
.meas tran vdout1_110ck101 FIND v(dout1_110) AT=510.025n

* CHECK dout1_111 Vdout1_111ck101 = 0.9 time = 510
.meas tran vdout1_111ck101 FIND v(dout1_111) AT=510.025n

* CHECK dout1_112 Vdout1_112ck101 = 0.9 time = 510
.meas tran vdout1_112ck101 FIND v(dout1_112) AT=510.025n

* CHECK dout1_113 Vdout1_113ck101 = 0.9 time = 510
.meas tran vdout1_113ck101 FIND v(dout1_113) AT=510.025n

* CHECK dout1_114 Vdout1_114ck101 = 0 time = 510
.meas tran vdout1_114ck101 FIND v(dout1_114) AT=510.025n

* CHECK dout1_115 Vdout1_115ck101 = 0.9 time = 510
.meas tran vdout1_115ck101 FIND v(dout1_115) AT=510.025n

* CHECK dout1_116 Vdout1_116ck101 = 0 time = 510
.meas tran vdout1_116ck101 FIND v(dout1_116) AT=510.025n

* CHECK dout1_117 Vdout1_117ck101 = 0.9 time = 510
.meas tran vdout1_117ck101 FIND v(dout1_117) AT=510.025n

* CHECK dout1_118 Vdout1_118ck101 = 0 time = 510
.meas tran vdout1_118ck101 FIND v(dout1_118) AT=510.025n

* CHECK dout1_119 Vdout1_119ck101 = 0 time = 510
.meas tran vdout1_119ck101 FIND v(dout1_119) AT=510.025n

* CHECK dout1_0 Vdout1_0ck102 = 0 time = 515
.meas tran vdout1_0ck102 FIND v(dout1_0) AT=515.025n

* CHECK dout1_1 Vdout1_1ck102 = 0 time = 515
.meas tran vdout1_1ck102 FIND v(dout1_1) AT=515.025n

* CHECK dout1_2 Vdout1_2ck102 = 0 time = 515
.meas tran vdout1_2ck102 FIND v(dout1_2) AT=515.025n

* CHECK dout1_3 Vdout1_3ck102 = 0.9 time = 515
.meas tran vdout1_3ck102 FIND v(dout1_3) AT=515.025n

* CHECK dout1_4 Vdout1_4ck102 = 0.9 time = 515
.meas tran vdout1_4ck102 FIND v(dout1_4) AT=515.025n

* CHECK dout1_5 Vdout1_5ck102 = 0 time = 515
.meas tran vdout1_5ck102 FIND v(dout1_5) AT=515.025n

* CHECK dout1_6 Vdout1_6ck102 = 0 time = 515
.meas tran vdout1_6ck102 FIND v(dout1_6) AT=515.025n

* CHECK dout1_7 Vdout1_7ck102 = 0 time = 515
.meas tran vdout1_7ck102 FIND v(dout1_7) AT=515.025n

* CHECK dout1_8 Vdout1_8ck102 = 0 time = 515
.meas tran vdout1_8ck102 FIND v(dout1_8) AT=515.025n

* CHECK dout1_9 Vdout1_9ck102 = 0.9 time = 515
.meas tran vdout1_9ck102 FIND v(dout1_9) AT=515.025n

* CHECK dout1_10 Vdout1_10ck102 = 0 time = 515
.meas tran vdout1_10ck102 FIND v(dout1_10) AT=515.025n

* CHECK dout1_11 Vdout1_11ck102 = 0.9 time = 515
.meas tran vdout1_11ck102 FIND v(dout1_11) AT=515.025n

* CHECK dout1_12 Vdout1_12ck102 = 0 time = 515
.meas tran vdout1_12ck102 FIND v(dout1_12) AT=515.025n

* CHECK dout1_13 Vdout1_13ck102 = 0 time = 515
.meas tran vdout1_13ck102 FIND v(dout1_13) AT=515.025n

* CHECK dout1_14 Vdout1_14ck102 = 0.9 time = 515
.meas tran vdout1_14ck102 FIND v(dout1_14) AT=515.025n

* CHECK dout1_15 Vdout1_15ck102 = 0 time = 515
.meas tran vdout1_15ck102 FIND v(dout1_15) AT=515.025n

* CHECK dout1_16 Vdout1_16ck102 = 0 time = 515
.meas tran vdout1_16ck102 FIND v(dout1_16) AT=515.025n

* CHECK dout1_17 Vdout1_17ck102 = 0.9 time = 515
.meas tran vdout1_17ck102 FIND v(dout1_17) AT=515.025n

* CHECK dout1_18 Vdout1_18ck102 = 0 time = 515
.meas tran vdout1_18ck102 FIND v(dout1_18) AT=515.025n

* CHECK dout1_19 Vdout1_19ck102 = 0 time = 515
.meas tran vdout1_19ck102 FIND v(dout1_19) AT=515.025n

* CHECK dout1_20 Vdout1_20ck102 = 0 time = 515
.meas tran vdout1_20ck102 FIND v(dout1_20) AT=515.025n

* CHECK dout1_21 Vdout1_21ck102 = 0 time = 515
.meas tran vdout1_21ck102 FIND v(dout1_21) AT=515.025n

* CHECK dout1_22 Vdout1_22ck102 = 0 time = 515
.meas tran vdout1_22ck102 FIND v(dout1_22) AT=515.025n

* CHECK dout1_23 Vdout1_23ck102 = 0.9 time = 515
.meas tran vdout1_23ck102 FIND v(dout1_23) AT=515.025n

* CHECK dout1_24 Vdout1_24ck102 = 0 time = 515
.meas tran vdout1_24ck102 FIND v(dout1_24) AT=515.025n

* CHECK dout1_25 Vdout1_25ck102 = 0.9 time = 515
.meas tran vdout1_25ck102 FIND v(dout1_25) AT=515.025n

* CHECK dout1_26 Vdout1_26ck102 = 0 time = 515
.meas tran vdout1_26ck102 FIND v(dout1_26) AT=515.025n

* CHECK dout1_27 Vdout1_27ck102 = 0 time = 515
.meas tran vdout1_27ck102 FIND v(dout1_27) AT=515.025n

* CHECK dout1_28 Vdout1_28ck102 = 0.9 time = 515
.meas tran vdout1_28ck102 FIND v(dout1_28) AT=515.025n

* CHECK dout1_29 Vdout1_29ck102 = 0.9 time = 515
.meas tran vdout1_29ck102 FIND v(dout1_29) AT=515.025n

* CHECK dout1_30 Vdout1_30ck102 = 0.9 time = 515
.meas tran vdout1_30ck102 FIND v(dout1_30) AT=515.025n

* CHECK dout1_31 Vdout1_31ck102 = 0.9 time = 515
.meas tran vdout1_31ck102 FIND v(dout1_31) AT=515.025n

* CHECK dout1_32 Vdout1_32ck102 = 0.9 time = 515
.meas tran vdout1_32ck102 FIND v(dout1_32) AT=515.025n

* CHECK dout1_33 Vdout1_33ck102 = 0 time = 515
.meas tran vdout1_33ck102 FIND v(dout1_33) AT=515.025n

* CHECK dout1_34 Vdout1_34ck102 = 0.9 time = 515
.meas tran vdout1_34ck102 FIND v(dout1_34) AT=515.025n

* CHECK dout1_35 Vdout1_35ck102 = 0 time = 515
.meas tran vdout1_35ck102 FIND v(dout1_35) AT=515.025n

* CHECK dout1_36 Vdout1_36ck102 = 0.9 time = 515
.meas tran vdout1_36ck102 FIND v(dout1_36) AT=515.025n

* CHECK dout1_37 Vdout1_37ck102 = 0.9 time = 515
.meas tran vdout1_37ck102 FIND v(dout1_37) AT=515.025n

* CHECK dout1_38 Vdout1_38ck102 = 0 time = 515
.meas tran vdout1_38ck102 FIND v(dout1_38) AT=515.025n

* CHECK dout1_39 Vdout1_39ck102 = 0 time = 515
.meas tran vdout1_39ck102 FIND v(dout1_39) AT=515.025n

* CHECK dout1_40 Vdout1_40ck102 = 0.9 time = 515
.meas tran vdout1_40ck102 FIND v(dout1_40) AT=515.025n

* CHECK dout1_41 Vdout1_41ck102 = 0.9 time = 515
.meas tran vdout1_41ck102 FIND v(dout1_41) AT=515.025n

* CHECK dout1_42 Vdout1_42ck102 = 0 time = 515
.meas tran vdout1_42ck102 FIND v(dout1_42) AT=515.025n

* CHECK dout1_43 Vdout1_43ck102 = 0 time = 515
.meas tran vdout1_43ck102 FIND v(dout1_43) AT=515.025n

* CHECK dout1_44 Vdout1_44ck102 = 0 time = 515
.meas tran vdout1_44ck102 FIND v(dout1_44) AT=515.025n

* CHECK dout1_45 Vdout1_45ck102 = 0 time = 515
.meas tran vdout1_45ck102 FIND v(dout1_45) AT=515.025n

* CHECK dout1_46 Vdout1_46ck102 = 0 time = 515
.meas tran vdout1_46ck102 FIND v(dout1_46) AT=515.025n

* CHECK dout1_47 Vdout1_47ck102 = 0 time = 515
.meas tran vdout1_47ck102 FIND v(dout1_47) AT=515.025n

* CHECK dout1_48 Vdout1_48ck102 = 0 time = 515
.meas tran vdout1_48ck102 FIND v(dout1_48) AT=515.025n

* CHECK dout1_49 Vdout1_49ck102 = 0.9 time = 515
.meas tran vdout1_49ck102 FIND v(dout1_49) AT=515.025n

* CHECK dout1_50 Vdout1_50ck102 = 0 time = 515
.meas tran vdout1_50ck102 FIND v(dout1_50) AT=515.025n

* CHECK dout1_51 Vdout1_51ck102 = 0.9 time = 515
.meas tran vdout1_51ck102 FIND v(dout1_51) AT=515.025n

* CHECK dout1_52 Vdout1_52ck102 = 0.9 time = 515
.meas tran vdout1_52ck102 FIND v(dout1_52) AT=515.025n

* CHECK dout1_53 Vdout1_53ck102 = 0.9 time = 515
.meas tran vdout1_53ck102 FIND v(dout1_53) AT=515.025n

* CHECK dout1_54 Vdout1_54ck102 = 0.9 time = 515
.meas tran vdout1_54ck102 FIND v(dout1_54) AT=515.025n

* CHECK dout1_55 Vdout1_55ck102 = 0 time = 515
.meas tran vdout1_55ck102 FIND v(dout1_55) AT=515.025n

* CHECK dout1_56 Vdout1_56ck102 = 0.9 time = 515
.meas tran vdout1_56ck102 FIND v(dout1_56) AT=515.025n

* CHECK dout1_57 Vdout1_57ck102 = 0.9 time = 515
.meas tran vdout1_57ck102 FIND v(dout1_57) AT=515.025n

* CHECK dout1_58 Vdout1_58ck102 = 0 time = 515
.meas tran vdout1_58ck102 FIND v(dout1_58) AT=515.025n

* CHECK dout1_59 Vdout1_59ck102 = 0.9 time = 515
.meas tran vdout1_59ck102 FIND v(dout1_59) AT=515.025n

* CHECK dout1_60 Vdout1_60ck102 = 0 time = 515
.meas tran vdout1_60ck102 FIND v(dout1_60) AT=515.025n

* CHECK dout1_61 Vdout1_61ck102 = 0.9 time = 515
.meas tran vdout1_61ck102 FIND v(dout1_61) AT=515.025n

* CHECK dout1_62 Vdout1_62ck102 = 0 time = 515
.meas tran vdout1_62ck102 FIND v(dout1_62) AT=515.025n

* CHECK dout1_63 Vdout1_63ck102 = 0.9 time = 515
.meas tran vdout1_63ck102 FIND v(dout1_63) AT=515.025n

* CHECK dout1_64 Vdout1_64ck102 = 0.9 time = 515
.meas tran vdout1_64ck102 FIND v(dout1_64) AT=515.025n

* CHECK dout1_65 Vdout1_65ck102 = 0.9 time = 515
.meas tran vdout1_65ck102 FIND v(dout1_65) AT=515.025n

* CHECK dout1_66 Vdout1_66ck102 = 0.9 time = 515
.meas tran vdout1_66ck102 FIND v(dout1_66) AT=515.025n

* CHECK dout1_67 Vdout1_67ck102 = 0.9 time = 515
.meas tran vdout1_67ck102 FIND v(dout1_67) AT=515.025n

* CHECK dout1_68 Vdout1_68ck102 = 0.9 time = 515
.meas tran vdout1_68ck102 FIND v(dout1_68) AT=515.025n

* CHECK dout1_69 Vdout1_69ck102 = 0 time = 515
.meas tran vdout1_69ck102 FIND v(dout1_69) AT=515.025n

* CHECK dout1_70 Vdout1_70ck102 = 0.9 time = 515
.meas tran vdout1_70ck102 FIND v(dout1_70) AT=515.025n

* CHECK dout1_71 Vdout1_71ck102 = 0.9 time = 515
.meas tran vdout1_71ck102 FIND v(dout1_71) AT=515.025n

* CHECK dout1_72 Vdout1_72ck102 = 0.9 time = 515
.meas tran vdout1_72ck102 FIND v(dout1_72) AT=515.025n

* CHECK dout1_73 Vdout1_73ck102 = 0 time = 515
.meas tran vdout1_73ck102 FIND v(dout1_73) AT=515.025n

* CHECK dout1_74 Vdout1_74ck102 = 0 time = 515
.meas tran vdout1_74ck102 FIND v(dout1_74) AT=515.025n

* CHECK dout1_75 Vdout1_75ck102 = 0.9 time = 515
.meas tran vdout1_75ck102 FIND v(dout1_75) AT=515.025n

* CHECK dout1_76 Vdout1_76ck102 = 0 time = 515
.meas tran vdout1_76ck102 FIND v(dout1_76) AT=515.025n

* CHECK dout1_77 Vdout1_77ck102 = 0.9 time = 515
.meas tran vdout1_77ck102 FIND v(dout1_77) AT=515.025n

* CHECK dout1_78 Vdout1_78ck102 = 0.9 time = 515
.meas tran vdout1_78ck102 FIND v(dout1_78) AT=515.025n

* CHECK dout1_79 Vdout1_79ck102 = 0 time = 515
.meas tran vdout1_79ck102 FIND v(dout1_79) AT=515.025n

* CHECK dout1_80 Vdout1_80ck102 = 0 time = 515
.meas tran vdout1_80ck102 FIND v(dout1_80) AT=515.025n

* CHECK dout1_81 Vdout1_81ck102 = 0 time = 515
.meas tran vdout1_81ck102 FIND v(dout1_81) AT=515.025n

* CHECK dout1_82 Vdout1_82ck102 = 0 time = 515
.meas tran vdout1_82ck102 FIND v(dout1_82) AT=515.025n

* CHECK dout1_83 Vdout1_83ck102 = 0 time = 515
.meas tran vdout1_83ck102 FIND v(dout1_83) AT=515.025n

* CHECK dout1_84 Vdout1_84ck102 = 0 time = 515
.meas tran vdout1_84ck102 FIND v(dout1_84) AT=515.025n

* CHECK dout1_85 Vdout1_85ck102 = 0.9 time = 515
.meas tran vdout1_85ck102 FIND v(dout1_85) AT=515.025n

* CHECK dout1_86 Vdout1_86ck102 = 0.9 time = 515
.meas tran vdout1_86ck102 FIND v(dout1_86) AT=515.025n

* CHECK dout1_87 Vdout1_87ck102 = 0.9 time = 515
.meas tran vdout1_87ck102 FIND v(dout1_87) AT=515.025n

* CHECK dout1_88 Vdout1_88ck102 = 0 time = 515
.meas tran vdout1_88ck102 FIND v(dout1_88) AT=515.025n

* CHECK dout1_89 Vdout1_89ck102 = 0 time = 515
.meas tran vdout1_89ck102 FIND v(dout1_89) AT=515.025n

* CHECK dout1_90 Vdout1_90ck102 = 0.9 time = 515
.meas tran vdout1_90ck102 FIND v(dout1_90) AT=515.025n

* CHECK dout1_91 Vdout1_91ck102 = 0.9 time = 515
.meas tran vdout1_91ck102 FIND v(dout1_91) AT=515.025n

* CHECK dout1_92 Vdout1_92ck102 = 0 time = 515
.meas tran vdout1_92ck102 FIND v(dout1_92) AT=515.025n

* CHECK dout1_93 Vdout1_93ck102 = 0.9 time = 515
.meas tran vdout1_93ck102 FIND v(dout1_93) AT=515.025n

* CHECK dout1_94 Vdout1_94ck102 = 0.9 time = 515
.meas tran vdout1_94ck102 FIND v(dout1_94) AT=515.025n

* CHECK dout1_95 Vdout1_95ck102 = 0.9 time = 515
.meas tran vdout1_95ck102 FIND v(dout1_95) AT=515.025n

* CHECK dout1_96 Vdout1_96ck102 = 0 time = 515
.meas tran vdout1_96ck102 FIND v(dout1_96) AT=515.025n

* CHECK dout1_97 Vdout1_97ck102 = 0 time = 515
.meas tran vdout1_97ck102 FIND v(dout1_97) AT=515.025n

* CHECK dout1_98 Vdout1_98ck102 = 0 time = 515
.meas tran vdout1_98ck102 FIND v(dout1_98) AT=515.025n

* CHECK dout1_99 Vdout1_99ck102 = 0.9 time = 515
.meas tran vdout1_99ck102 FIND v(dout1_99) AT=515.025n

* CHECK dout1_100 Vdout1_100ck102 = 0 time = 515
.meas tran vdout1_100ck102 FIND v(dout1_100) AT=515.025n

* CHECK dout1_101 Vdout1_101ck102 = 0.9 time = 515
.meas tran vdout1_101ck102 FIND v(dout1_101) AT=515.025n

* CHECK dout1_102 Vdout1_102ck102 = 0.9 time = 515
.meas tran vdout1_102ck102 FIND v(dout1_102) AT=515.025n

* CHECK dout1_103 Vdout1_103ck102 = 0 time = 515
.meas tran vdout1_103ck102 FIND v(dout1_103) AT=515.025n

* CHECK dout1_104 Vdout1_104ck102 = 0 time = 515
.meas tran vdout1_104ck102 FIND v(dout1_104) AT=515.025n

* CHECK dout1_105 Vdout1_105ck102 = 0 time = 515
.meas tran vdout1_105ck102 FIND v(dout1_105) AT=515.025n

* CHECK dout1_106 Vdout1_106ck102 = 0 time = 515
.meas tran vdout1_106ck102 FIND v(dout1_106) AT=515.025n

* CHECK dout1_107 Vdout1_107ck102 = 0 time = 515
.meas tran vdout1_107ck102 FIND v(dout1_107) AT=515.025n

* CHECK dout1_108 Vdout1_108ck102 = 0 time = 515
.meas tran vdout1_108ck102 FIND v(dout1_108) AT=515.025n

* CHECK dout1_109 Vdout1_109ck102 = 0.9 time = 515
.meas tran vdout1_109ck102 FIND v(dout1_109) AT=515.025n

* CHECK dout1_110 Vdout1_110ck102 = 0 time = 515
.meas tran vdout1_110ck102 FIND v(dout1_110) AT=515.025n

* CHECK dout1_111 Vdout1_111ck102 = 0.9 time = 515
.meas tran vdout1_111ck102 FIND v(dout1_111) AT=515.025n

* CHECK dout1_112 Vdout1_112ck102 = 0.9 time = 515
.meas tran vdout1_112ck102 FIND v(dout1_112) AT=515.025n

* CHECK dout1_113 Vdout1_113ck102 = 0.9 time = 515
.meas tran vdout1_113ck102 FIND v(dout1_113) AT=515.025n

* CHECK dout1_114 Vdout1_114ck102 = 0 time = 515
.meas tran vdout1_114ck102 FIND v(dout1_114) AT=515.025n

* CHECK dout1_115 Vdout1_115ck102 = 0.9 time = 515
.meas tran vdout1_115ck102 FIND v(dout1_115) AT=515.025n

* CHECK dout1_116 Vdout1_116ck102 = 0 time = 515
.meas tran vdout1_116ck102 FIND v(dout1_116) AT=515.025n

* CHECK dout1_117 Vdout1_117ck102 = 0.9 time = 515
.meas tran vdout1_117ck102 FIND v(dout1_117) AT=515.025n

* CHECK dout1_118 Vdout1_118ck102 = 0 time = 515
.meas tran vdout1_118ck102 FIND v(dout1_118) AT=515.025n

* CHECK dout1_119 Vdout1_119ck102 = 0 time = 515
.meas tran vdout1_119ck102 FIND v(dout1_119) AT=515.025n

* CHECK dout1_0 Vdout1_0ck103 = 0 time = 520
.meas tran vdout1_0ck103 FIND v(dout1_0) AT=520.025n

* CHECK dout1_1 Vdout1_1ck103 = 0 time = 520
.meas tran vdout1_1ck103 FIND v(dout1_1) AT=520.025n

* CHECK dout1_2 Vdout1_2ck103 = 0 time = 520
.meas tran vdout1_2ck103 FIND v(dout1_2) AT=520.025n

* CHECK dout1_3 Vdout1_3ck103 = 0.9 time = 520
.meas tran vdout1_3ck103 FIND v(dout1_3) AT=520.025n

* CHECK dout1_4 Vdout1_4ck103 = 0.9 time = 520
.meas tran vdout1_4ck103 FIND v(dout1_4) AT=520.025n

* CHECK dout1_5 Vdout1_5ck103 = 0 time = 520
.meas tran vdout1_5ck103 FIND v(dout1_5) AT=520.025n

* CHECK dout1_6 Vdout1_6ck103 = 0 time = 520
.meas tran vdout1_6ck103 FIND v(dout1_6) AT=520.025n

* CHECK dout1_7 Vdout1_7ck103 = 0 time = 520
.meas tran vdout1_7ck103 FIND v(dout1_7) AT=520.025n

* CHECK dout1_8 Vdout1_8ck103 = 0 time = 520
.meas tran vdout1_8ck103 FIND v(dout1_8) AT=520.025n

* CHECK dout1_9 Vdout1_9ck103 = 0.9 time = 520
.meas tran vdout1_9ck103 FIND v(dout1_9) AT=520.025n

* CHECK dout1_10 Vdout1_10ck103 = 0 time = 520
.meas tran vdout1_10ck103 FIND v(dout1_10) AT=520.025n

* CHECK dout1_11 Vdout1_11ck103 = 0.9 time = 520
.meas tran vdout1_11ck103 FIND v(dout1_11) AT=520.025n

* CHECK dout1_12 Vdout1_12ck103 = 0 time = 520
.meas tran vdout1_12ck103 FIND v(dout1_12) AT=520.025n

* CHECK dout1_13 Vdout1_13ck103 = 0 time = 520
.meas tran vdout1_13ck103 FIND v(dout1_13) AT=520.025n

* CHECK dout1_14 Vdout1_14ck103 = 0.9 time = 520
.meas tran vdout1_14ck103 FIND v(dout1_14) AT=520.025n

* CHECK dout1_15 Vdout1_15ck103 = 0 time = 520
.meas tran vdout1_15ck103 FIND v(dout1_15) AT=520.025n

* CHECK dout1_16 Vdout1_16ck103 = 0 time = 520
.meas tran vdout1_16ck103 FIND v(dout1_16) AT=520.025n

* CHECK dout1_17 Vdout1_17ck103 = 0.9 time = 520
.meas tran vdout1_17ck103 FIND v(dout1_17) AT=520.025n

* CHECK dout1_18 Vdout1_18ck103 = 0 time = 520
.meas tran vdout1_18ck103 FIND v(dout1_18) AT=520.025n

* CHECK dout1_19 Vdout1_19ck103 = 0 time = 520
.meas tran vdout1_19ck103 FIND v(dout1_19) AT=520.025n

* CHECK dout1_20 Vdout1_20ck103 = 0 time = 520
.meas tran vdout1_20ck103 FIND v(dout1_20) AT=520.025n

* CHECK dout1_21 Vdout1_21ck103 = 0 time = 520
.meas tran vdout1_21ck103 FIND v(dout1_21) AT=520.025n

* CHECK dout1_22 Vdout1_22ck103 = 0 time = 520
.meas tran vdout1_22ck103 FIND v(dout1_22) AT=520.025n

* CHECK dout1_23 Vdout1_23ck103 = 0.9 time = 520
.meas tran vdout1_23ck103 FIND v(dout1_23) AT=520.025n

* CHECK dout1_24 Vdout1_24ck103 = 0 time = 520
.meas tran vdout1_24ck103 FIND v(dout1_24) AT=520.025n

* CHECK dout1_25 Vdout1_25ck103 = 0.9 time = 520
.meas tran vdout1_25ck103 FIND v(dout1_25) AT=520.025n

* CHECK dout1_26 Vdout1_26ck103 = 0 time = 520
.meas tran vdout1_26ck103 FIND v(dout1_26) AT=520.025n

* CHECK dout1_27 Vdout1_27ck103 = 0 time = 520
.meas tran vdout1_27ck103 FIND v(dout1_27) AT=520.025n

* CHECK dout1_28 Vdout1_28ck103 = 0.9 time = 520
.meas tran vdout1_28ck103 FIND v(dout1_28) AT=520.025n

* CHECK dout1_29 Vdout1_29ck103 = 0.9 time = 520
.meas tran vdout1_29ck103 FIND v(dout1_29) AT=520.025n

* CHECK dout1_30 Vdout1_30ck103 = 0.9 time = 520
.meas tran vdout1_30ck103 FIND v(dout1_30) AT=520.025n

* CHECK dout1_31 Vdout1_31ck103 = 0.9 time = 520
.meas tran vdout1_31ck103 FIND v(dout1_31) AT=520.025n

* CHECK dout1_32 Vdout1_32ck103 = 0.9 time = 520
.meas tran vdout1_32ck103 FIND v(dout1_32) AT=520.025n

* CHECK dout1_33 Vdout1_33ck103 = 0 time = 520
.meas tran vdout1_33ck103 FIND v(dout1_33) AT=520.025n

* CHECK dout1_34 Vdout1_34ck103 = 0.9 time = 520
.meas tran vdout1_34ck103 FIND v(dout1_34) AT=520.025n

* CHECK dout1_35 Vdout1_35ck103 = 0 time = 520
.meas tran vdout1_35ck103 FIND v(dout1_35) AT=520.025n

* CHECK dout1_36 Vdout1_36ck103 = 0.9 time = 520
.meas tran vdout1_36ck103 FIND v(dout1_36) AT=520.025n

* CHECK dout1_37 Vdout1_37ck103 = 0.9 time = 520
.meas tran vdout1_37ck103 FIND v(dout1_37) AT=520.025n

* CHECK dout1_38 Vdout1_38ck103 = 0 time = 520
.meas tran vdout1_38ck103 FIND v(dout1_38) AT=520.025n

* CHECK dout1_39 Vdout1_39ck103 = 0 time = 520
.meas tran vdout1_39ck103 FIND v(dout1_39) AT=520.025n

* CHECK dout1_40 Vdout1_40ck103 = 0.9 time = 520
.meas tran vdout1_40ck103 FIND v(dout1_40) AT=520.025n

* CHECK dout1_41 Vdout1_41ck103 = 0.9 time = 520
.meas tran vdout1_41ck103 FIND v(dout1_41) AT=520.025n

* CHECK dout1_42 Vdout1_42ck103 = 0 time = 520
.meas tran vdout1_42ck103 FIND v(dout1_42) AT=520.025n

* CHECK dout1_43 Vdout1_43ck103 = 0 time = 520
.meas tran vdout1_43ck103 FIND v(dout1_43) AT=520.025n

* CHECK dout1_44 Vdout1_44ck103 = 0 time = 520
.meas tran vdout1_44ck103 FIND v(dout1_44) AT=520.025n

* CHECK dout1_45 Vdout1_45ck103 = 0 time = 520
.meas tran vdout1_45ck103 FIND v(dout1_45) AT=520.025n

* CHECK dout1_46 Vdout1_46ck103 = 0 time = 520
.meas tran vdout1_46ck103 FIND v(dout1_46) AT=520.025n

* CHECK dout1_47 Vdout1_47ck103 = 0 time = 520
.meas tran vdout1_47ck103 FIND v(dout1_47) AT=520.025n

* CHECK dout1_48 Vdout1_48ck103 = 0 time = 520
.meas tran vdout1_48ck103 FIND v(dout1_48) AT=520.025n

* CHECK dout1_49 Vdout1_49ck103 = 0.9 time = 520
.meas tran vdout1_49ck103 FIND v(dout1_49) AT=520.025n

* CHECK dout1_50 Vdout1_50ck103 = 0 time = 520
.meas tran vdout1_50ck103 FIND v(dout1_50) AT=520.025n

* CHECK dout1_51 Vdout1_51ck103 = 0.9 time = 520
.meas tran vdout1_51ck103 FIND v(dout1_51) AT=520.025n

* CHECK dout1_52 Vdout1_52ck103 = 0.9 time = 520
.meas tran vdout1_52ck103 FIND v(dout1_52) AT=520.025n

* CHECK dout1_53 Vdout1_53ck103 = 0.9 time = 520
.meas tran vdout1_53ck103 FIND v(dout1_53) AT=520.025n

* CHECK dout1_54 Vdout1_54ck103 = 0.9 time = 520
.meas tran vdout1_54ck103 FIND v(dout1_54) AT=520.025n

* CHECK dout1_55 Vdout1_55ck103 = 0 time = 520
.meas tran vdout1_55ck103 FIND v(dout1_55) AT=520.025n

* CHECK dout1_56 Vdout1_56ck103 = 0.9 time = 520
.meas tran vdout1_56ck103 FIND v(dout1_56) AT=520.025n

* CHECK dout1_57 Vdout1_57ck103 = 0.9 time = 520
.meas tran vdout1_57ck103 FIND v(dout1_57) AT=520.025n

* CHECK dout1_58 Vdout1_58ck103 = 0 time = 520
.meas tran vdout1_58ck103 FIND v(dout1_58) AT=520.025n

* CHECK dout1_59 Vdout1_59ck103 = 0.9 time = 520
.meas tran vdout1_59ck103 FIND v(dout1_59) AT=520.025n

* CHECK dout1_60 Vdout1_60ck103 = 0 time = 520
.meas tran vdout1_60ck103 FIND v(dout1_60) AT=520.025n

* CHECK dout1_61 Vdout1_61ck103 = 0.9 time = 520
.meas tran vdout1_61ck103 FIND v(dout1_61) AT=520.025n

* CHECK dout1_62 Vdout1_62ck103 = 0 time = 520
.meas tran vdout1_62ck103 FIND v(dout1_62) AT=520.025n

* CHECK dout1_63 Vdout1_63ck103 = 0.9 time = 520
.meas tran vdout1_63ck103 FIND v(dout1_63) AT=520.025n

* CHECK dout1_64 Vdout1_64ck103 = 0.9 time = 520
.meas tran vdout1_64ck103 FIND v(dout1_64) AT=520.025n

* CHECK dout1_65 Vdout1_65ck103 = 0.9 time = 520
.meas tran vdout1_65ck103 FIND v(dout1_65) AT=520.025n

* CHECK dout1_66 Vdout1_66ck103 = 0.9 time = 520
.meas tran vdout1_66ck103 FIND v(dout1_66) AT=520.025n

* CHECK dout1_67 Vdout1_67ck103 = 0.9 time = 520
.meas tran vdout1_67ck103 FIND v(dout1_67) AT=520.025n

* CHECK dout1_68 Vdout1_68ck103 = 0.9 time = 520
.meas tran vdout1_68ck103 FIND v(dout1_68) AT=520.025n

* CHECK dout1_69 Vdout1_69ck103 = 0 time = 520
.meas tran vdout1_69ck103 FIND v(dout1_69) AT=520.025n

* CHECK dout1_70 Vdout1_70ck103 = 0.9 time = 520
.meas tran vdout1_70ck103 FIND v(dout1_70) AT=520.025n

* CHECK dout1_71 Vdout1_71ck103 = 0.9 time = 520
.meas tran vdout1_71ck103 FIND v(dout1_71) AT=520.025n

* CHECK dout1_72 Vdout1_72ck103 = 0.9 time = 520
.meas tran vdout1_72ck103 FIND v(dout1_72) AT=520.025n

* CHECK dout1_73 Vdout1_73ck103 = 0 time = 520
.meas tran vdout1_73ck103 FIND v(dout1_73) AT=520.025n

* CHECK dout1_74 Vdout1_74ck103 = 0 time = 520
.meas tran vdout1_74ck103 FIND v(dout1_74) AT=520.025n

* CHECK dout1_75 Vdout1_75ck103 = 0.9 time = 520
.meas tran vdout1_75ck103 FIND v(dout1_75) AT=520.025n

* CHECK dout1_76 Vdout1_76ck103 = 0 time = 520
.meas tran vdout1_76ck103 FIND v(dout1_76) AT=520.025n

* CHECK dout1_77 Vdout1_77ck103 = 0.9 time = 520
.meas tran vdout1_77ck103 FIND v(dout1_77) AT=520.025n

* CHECK dout1_78 Vdout1_78ck103 = 0.9 time = 520
.meas tran vdout1_78ck103 FIND v(dout1_78) AT=520.025n

* CHECK dout1_79 Vdout1_79ck103 = 0 time = 520
.meas tran vdout1_79ck103 FIND v(dout1_79) AT=520.025n

* CHECK dout1_80 Vdout1_80ck103 = 0 time = 520
.meas tran vdout1_80ck103 FIND v(dout1_80) AT=520.025n

* CHECK dout1_81 Vdout1_81ck103 = 0 time = 520
.meas tran vdout1_81ck103 FIND v(dout1_81) AT=520.025n

* CHECK dout1_82 Vdout1_82ck103 = 0 time = 520
.meas tran vdout1_82ck103 FIND v(dout1_82) AT=520.025n

* CHECK dout1_83 Vdout1_83ck103 = 0 time = 520
.meas tran vdout1_83ck103 FIND v(dout1_83) AT=520.025n

* CHECK dout1_84 Vdout1_84ck103 = 0 time = 520
.meas tran vdout1_84ck103 FIND v(dout1_84) AT=520.025n

* CHECK dout1_85 Vdout1_85ck103 = 0.9 time = 520
.meas tran vdout1_85ck103 FIND v(dout1_85) AT=520.025n

* CHECK dout1_86 Vdout1_86ck103 = 0.9 time = 520
.meas tran vdout1_86ck103 FIND v(dout1_86) AT=520.025n

* CHECK dout1_87 Vdout1_87ck103 = 0.9 time = 520
.meas tran vdout1_87ck103 FIND v(dout1_87) AT=520.025n

* CHECK dout1_88 Vdout1_88ck103 = 0 time = 520
.meas tran vdout1_88ck103 FIND v(dout1_88) AT=520.025n

* CHECK dout1_89 Vdout1_89ck103 = 0 time = 520
.meas tran vdout1_89ck103 FIND v(dout1_89) AT=520.025n

* CHECK dout1_90 Vdout1_90ck103 = 0.9 time = 520
.meas tran vdout1_90ck103 FIND v(dout1_90) AT=520.025n

* CHECK dout1_91 Vdout1_91ck103 = 0.9 time = 520
.meas tran vdout1_91ck103 FIND v(dout1_91) AT=520.025n

* CHECK dout1_92 Vdout1_92ck103 = 0 time = 520
.meas tran vdout1_92ck103 FIND v(dout1_92) AT=520.025n

* CHECK dout1_93 Vdout1_93ck103 = 0.9 time = 520
.meas tran vdout1_93ck103 FIND v(dout1_93) AT=520.025n

* CHECK dout1_94 Vdout1_94ck103 = 0.9 time = 520
.meas tran vdout1_94ck103 FIND v(dout1_94) AT=520.025n

* CHECK dout1_95 Vdout1_95ck103 = 0.9 time = 520
.meas tran vdout1_95ck103 FIND v(dout1_95) AT=520.025n

* CHECK dout1_96 Vdout1_96ck103 = 0 time = 520
.meas tran vdout1_96ck103 FIND v(dout1_96) AT=520.025n

* CHECK dout1_97 Vdout1_97ck103 = 0 time = 520
.meas tran vdout1_97ck103 FIND v(dout1_97) AT=520.025n

* CHECK dout1_98 Vdout1_98ck103 = 0 time = 520
.meas tran vdout1_98ck103 FIND v(dout1_98) AT=520.025n

* CHECK dout1_99 Vdout1_99ck103 = 0.9 time = 520
.meas tran vdout1_99ck103 FIND v(dout1_99) AT=520.025n

* CHECK dout1_100 Vdout1_100ck103 = 0 time = 520
.meas tran vdout1_100ck103 FIND v(dout1_100) AT=520.025n

* CHECK dout1_101 Vdout1_101ck103 = 0.9 time = 520
.meas tran vdout1_101ck103 FIND v(dout1_101) AT=520.025n

* CHECK dout1_102 Vdout1_102ck103 = 0.9 time = 520
.meas tran vdout1_102ck103 FIND v(dout1_102) AT=520.025n

* CHECK dout1_103 Vdout1_103ck103 = 0 time = 520
.meas tran vdout1_103ck103 FIND v(dout1_103) AT=520.025n

* CHECK dout1_104 Vdout1_104ck103 = 0 time = 520
.meas tran vdout1_104ck103 FIND v(dout1_104) AT=520.025n

* CHECK dout1_105 Vdout1_105ck103 = 0 time = 520
.meas tran vdout1_105ck103 FIND v(dout1_105) AT=520.025n

* CHECK dout1_106 Vdout1_106ck103 = 0 time = 520
.meas tran vdout1_106ck103 FIND v(dout1_106) AT=520.025n

* CHECK dout1_107 Vdout1_107ck103 = 0 time = 520
.meas tran vdout1_107ck103 FIND v(dout1_107) AT=520.025n

* CHECK dout1_108 Vdout1_108ck103 = 0 time = 520
.meas tran vdout1_108ck103 FIND v(dout1_108) AT=520.025n

* CHECK dout1_109 Vdout1_109ck103 = 0.9 time = 520
.meas tran vdout1_109ck103 FIND v(dout1_109) AT=520.025n

* CHECK dout1_110 Vdout1_110ck103 = 0 time = 520
.meas tran vdout1_110ck103 FIND v(dout1_110) AT=520.025n

* CHECK dout1_111 Vdout1_111ck103 = 0.9 time = 520
.meas tran vdout1_111ck103 FIND v(dout1_111) AT=520.025n

* CHECK dout1_112 Vdout1_112ck103 = 0.9 time = 520
.meas tran vdout1_112ck103 FIND v(dout1_112) AT=520.025n

* CHECK dout1_113 Vdout1_113ck103 = 0.9 time = 520
.meas tran vdout1_113ck103 FIND v(dout1_113) AT=520.025n

* CHECK dout1_114 Vdout1_114ck103 = 0 time = 520
.meas tran vdout1_114ck103 FIND v(dout1_114) AT=520.025n

* CHECK dout1_115 Vdout1_115ck103 = 0.9 time = 520
.meas tran vdout1_115ck103 FIND v(dout1_115) AT=520.025n

* CHECK dout1_116 Vdout1_116ck103 = 0 time = 520
.meas tran vdout1_116ck103 FIND v(dout1_116) AT=520.025n

* CHECK dout1_117 Vdout1_117ck103 = 0.9 time = 520
.meas tran vdout1_117ck103 FIND v(dout1_117) AT=520.025n

* CHECK dout1_118 Vdout1_118ck103 = 0 time = 520
.meas tran vdout1_118ck103 FIND v(dout1_118) AT=520.025n

* CHECK dout1_119 Vdout1_119ck103 = 0 time = 520
.meas tran vdout1_119ck103 FIND v(dout1_119) AT=520.025n

* CHECK dout1_0 Vdout1_0ck104 = 0 time = 525
.meas tran vdout1_0ck104 FIND v(dout1_0) AT=525.025n

* CHECK dout1_1 Vdout1_1ck104 = 0.9 time = 525
.meas tran vdout1_1ck104 FIND v(dout1_1) AT=525.025n

* CHECK dout1_2 Vdout1_2ck104 = 0 time = 525
.meas tran vdout1_2ck104 FIND v(dout1_2) AT=525.025n

* CHECK dout1_3 Vdout1_3ck104 = 0 time = 525
.meas tran vdout1_3ck104 FIND v(dout1_3) AT=525.025n

* CHECK dout1_4 Vdout1_4ck104 = 0 time = 525
.meas tran vdout1_4ck104 FIND v(dout1_4) AT=525.025n

* CHECK dout1_5 Vdout1_5ck104 = 0 time = 525
.meas tran vdout1_5ck104 FIND v(dout1_5) AT=525.025n

* CHECK dout1_6 Vdout1_6ck104 = 0.9 time = 525
.meas tran vdout1_6ck104 FIND v(dout1_6) AT=525.025n

* CHECK dout1_7 Vdout1_7ck104 = 0 time = 525
.meas tran vdout1_7ck104 FIND v(dout1_7) AT=525.025n

* CHECK dout1_8 Vdout1_8ck104 = 0 time = 525
.meas tran vdout1_8ck104 FIND v(dout1_8) AT=525.025n

* CHECK dout1_9 Vdout1_9ck104 = 0 time = 525
.meas tran vdout1_9ck104 FIND v(dout1_9) AT=525.025n

* CHECK dout1_10 Vdout1_10ck104 = 0 time = 525
.meas tran vdout1_10ck104 FIND v(dout1_10) AT=525.025n

* CHECK dout1_11 Vdout1_11ck104 = 0.9 time = 525
.meas tran vdout1_11ck104 FIND v(dout1_11) AT=525.025n

* CHECK dout1_12 Vdout1_12ck104 = 0.9 time = 525
.meas tran vdout1_12ck104 FIND v(dout1_12) AT=525.025n

* CHECK dout1_13 Vdout1_13ck104 = 0.9 time = 525
.meas tran vdout1_13ck104 FIND v(dout1_13) AT=525.025n

* CHECK dout1_14 Vdout1_14ck104 = 0 time = 525
.meas tran vdout1_14ck104 FIND v(dout1_14) AT=525.025n

* CHECK dout1_15 Vdout1_15ck104 = 0.9 time = 525
.meas tran vdout1_15ck104 FIND v(dout1_15) AT=525.025n

* CHECK dout1_16 Vdout1_16ck104 = 0 time = 525
.meas tran vdout1_16ck104 FIND v(dout1_16) AT=525.025n

* CHECK dout1_17 Vdout1_17ck104 = 0 time = 525
.meas tran vdout1_17ck104 FIND v(dout1_17) AT=525.025n

* CHECK dout1_18 Vdout1_18ck104 = 0.9 time = 525
.meas tran vdout1_18ck104 FIND v(dout1_18) AT=525.025n

* CHECK dout1_19 Vdout1_19ck104 = 0.9 time = 525
.meas tran vdout1_19ck104 FIND v(dout1_19) AT=525.025n

* CHECK dout1_20 Vdout1_20ck104 = 0.9 time = 525
.meas tran vdout1_20ck104 FIND v(dout1_20) AT=525.025n

* CHECK dout1_21 Vdout1_21ck104 = 0.9 time = 525
.meas tran vdout1_21ck104 FIND v(dout1_21) AT=525.025n

* CHECK dout1_22 Vdout1_22ck104 = 0.9 time = 525
.meas tran vdout1_22ck104 FIND v(dout1_22) AT=525.025n

* CHECK dout1_23 Vdout1_23ck104 = 0 time = 525
.meas tran vdout1_23ck104 FIND v(dout1_23) AT=525.025n

* CHECK dout1_24 Vdout1_24ck104 = 0 time = 525
.meas tran vdout1_24ck104 FIND v(dout1_24) AT=525.025n

* CHECK dout1_25 Vdout1_25ck104 = 0.9 time = 525
.meas tran vdout1_25ck104 FIND v(dout1_25) AT=525.025n

* CHECK dout1_26 Vdout1_26ck104 = 0.9 time = 525
.meas tran vdout1_26ck104 FIND v(dout1_26) AT=525.025n

* CHECK dout1_27 Vdout1_27ck104 = 0 time = 525
.meas tran vdout1_27ck104 FIND v(dout1_27) AT=525.025n

* CHECK dout1_28 Vdout1_28ck104 = 0 time = 525
.meas tran vdout1_28ck104 FIND v(dout1_28) AT=525.025n

* CHECK dout1_29 Vdout1_29ck104 = 0 time = 525
.meas tran vdout1_29ck104 FIND v(dout1_29) AT=525.025n

* CHECK dout1_30 Vdout1_30ck104 = 0 time = 525
.meas tran vdout1_30ck104 FIND v(dout1_30) AT=525.025n

* CHECK dout1_31 Vdout1_31ck104 = 0.9 time = 525
.meas tran vdout1_31ck104 FIND v(dout1_31) AT=525.025n

* CHECK dout1_32 Vdout1_32ck104 = 0 time = 525
.meas tran vdout1_32ck104 FIND v(dout1_32) AT=525.025n

* CHECK dout1_33 Vdout1_33ck104 = 0.9 time = 525
.meas tran vdout1_33ck104 FIND v(dout1_33) AT=525.025n

* CHECK dout1_34 Vdout1_34ck104 = 0.9 time = 525
.meas tran vdout1_34ck104 FIND v(dout1_34) AT=525.025n

* CHECK dout1_35 Vdout1_35ck104 = 0 time = 525
.meas tran vdout1_35ck104 FIND v(dout1_35) AT=525.025n

* CHECK dout1_36 Vdout1_36ck104 = 0.9 time = 525
.meas tran vdout1_36ck104 FIND v(dout1_36) AT=525.025n

* CHECK dout1_37 Vdout1_37ck104 = 0.9 time = 525
.meas tran vdout1_37ck104 FIND v(dout1_37) AT=525.025n

* CHECK dout1_38 Vdout1_38ck104 = 0.9 time = 525
.meas tran vdout1_38ck104 FIND v(dout1_38) AT=525.025n

* CHECK dout1_39 Vdout1_39ck104 = 0 time = 525
.meas tran vdout1_39ck104 FIND v(dout1_39) AT=525.025n

* CHECK dout1_40 Vdout1_40ck104 = 0.9 time = 525
.meas tran vdout1_40ck104 FIND v(dout1_40) AT=525.025n

* CHECK dout1_41 Vdout1_41ck104 = 0.9 time = 525
.meas tran vdout1_41ck104 FIND v(dout1_41) AT=525.025n

* CHECK dout1_42 Vdout1_42ck104 = 0.9 time = 525
.meas tran vdout1_42ck104 FIND v(dout1_42) AT=525.025n

* CHECK dout1_43 Vdout1_43ck104 = 0.9 time = 525
.meas tran vdout1_43ck104 FIND v(dout1_43) AT=525.025n

* CHECK dout1_44 Vdout1_44ck104 = 0.9 time = 525
.meas tran vdout1_44ck104 FIND v(dout1_44) AT=525.025n

* CHECK dout1_45 Vdout1_45ck104 = 0.9 time = 525
.meas tran vdout1_45ck104 FIND v(dout1_45) AT=525.025n

* CHECK dout1_46 Vdout1_46ck104 = 0.9 time = 525
.meas tran vdout1_46ck104 FIND v(dout1_46) AT=525.025n

* CHECK dout1_47 Vdout1_47ck104 = 0.9 time = 525
.meas tran vdout1_47ck104 FIND v(dout1_47) AT=525.025n

* CHECK dout1_48 Vdout1_48ck104 = 0.9 time = 525
.meas tran vdout1_48ck104 FIND v(dout1_48) AT=525.025n

* CHECK dout1_49 Vdout1_49ck104 = 0 time = 525
.meas tran vdout1_49ck104 FIND v(dout1_49) AT=525.025n

* CHECK dout1_50 Vdout1_50ck104 = 0.9 time = 525
.meas tran vdout1_50ck104 FIND v(dout1_50) AT=525.025n

* CHECK dout1_51 Vdout1_51ck104 = 0 time = 525
.meas tran vdout1_51ck104 FIND v(dout1_51) AT=525.025n

* CHECK dout1_52 Vdout1_52ck104 = 0.9 time = 525
.meas tran vdout1_52ck104 FIND v(dout1_52) AT=525.025n

* CHECK dout1_53 Vdout1_53ck104 = 0 time = 525
.meas tran vdout1_53ck104 FIND v(dout1_53) AT=525.025n

* CHECK dout1_54 Vdout1_54ck104 = 0.9 time = 525
.meas tran vdout1_54ck104 FIND v(dout1_54) AT=525.025n

* CHECK dout1_55 Vdout1_55ck104 = 0.9 time = 525
.meas tran vdout1_55ck104 FIND v(dout1_55) AT=525.025n

* CHECK dout1_56 Vdout1_56ck104 = 0.9 time = 525
.meas tran vdout1_56ck104 FIND v(dout1_56) AT=525.025n

* CHECK dout1_57 Vdout1_57ck104 = 0 time = 525
.meas tran vdout1_57ck104 FIND v(dout1_57) AT=525.025n

* CHECK dout1_58 Vdout1_58ck104 = 0.9 time = 525
.meas tran vdout1_58ck104 FIND v(dout1_58) AT=525.025n

* CHECK dout1_59 Vdout1_59ck104 = 0 time = 525
.meas tran vdout1_59ck104 FIND v(dout1_59) AT=525.025n

* CHECK dout1_60 Vdout1_60ck104 = 0 time = 525
.meas tran vdout1_60ck104 FIND v(dout1_60) AT=525.025n

* CHECK dout1_61 Vdout1_61ck104 = 0.9 time = 525
.meas tran vdout1_61ck104 FIND v(dout1_61) AT=525.025n

* CHECK dout1_62 Vdout1_62ck104 = 0.9 time = 525
.meas tran vdout1_62ck104 FIND v(dout1_62) AT=525.025n

* CHECK dout1_63 Vdout1_63ck104 = 0 time = 525
.meas tran vdout1_63ck104 FIND v(dout1_63) AT=525.025n

* CHECK dout1_64 Vdout1_64ck104 = 0.9 time = 525
.meas tran vdout1_64ck104 FIND v(dout1_64) AT=525.025n

* CHECK dout1_65 Vdout1_65ck104 = 0 time = 525
.meas tran vdout1_65ck104 FIND v(dout1_65) AT=525.025n

* CHECK dout1_66 Vdout1_66ck104 = 0 time = 525
.meas tran vdout1_66ck104 FIND v(dout1_66) AT=525.025n

* CHECK dout1_67 Vdout1_67ck104 = 0 time = 525
.meas tran vdout1_67ck104 FIND v(dout1_67) AT=525.025n

* CHECK dout1_68 Vdout1_68ck104 = 0.9 time = 525
.meas tran vdout1_68ck104 FIND v(dout1_68) AT=525.025n

* CHECK dout1_69 Vdout1_69ck104 = 0 time = 525
.meas tran vdout1_69ck104 FIND v(dout1_69) AT=525.025n

* CHECK dout1_70 Vdout1_70ck104 = 0.9 time = 525
.meas tran vdout1_70ck104 FIND v(dout1_70) AT=525.025n

* CHECK dout1_71 Vdout1_71ck104 = 0.9 time = 525
.meas tran vdout1_71ck104 FIND v(dout1_71) AT=525.025n

* CHECK dout1_72 Vdout1_72ck104 = 0 time = 525
.meas tran vdout1_72ck104 FIND v(dout1_72) AT=525.025n

* CHECK dout1_73 Vdout1_73ck104 = 0.9 time = 525
.meas tran vdout1_73ck104 FIND v(dout1_73) AT=525.025n

* CHECK dout1_74 Vdout1_74ck104 = 0 time = 525
.meas tran vdout1_74ck104 FIND v(dout1_74) AT=525.025n

* CHECK dout1_75 Vdout1_75ck104 = 0.9 time = 525
.meas tran vdout1_75ck104 FIND v(dout1_75) AT=525.025n

* CHECK dout1_76 Vdout1_76ck104 = 0 time = 525
.meas tran vdout1_76ck104 FIND v(dout1_76) AT=525.025n

* CHECK dout1_77 Vdout1_77ck104 = 0 time = 525
.meas tran vdout1_77ck104 FIND v(dout1_77) AT=525.025n

* CHECK dout1_78 Vdout1_78ck104 = 0 time = 525
.meas tran vdout1_78ck104 FIND v(dout1_78) AT=525.025n

* CHECK dout1_79 Vdout1_79ck104 = 0.9 time = 525
.meas tran vdout1_79ck104 FIND v(dout1_79) AT=525.025n

* CHECK dout1_80 Vdout1_80ck104 = 0 time = 525
.meas tran vdout1_80ck104 FIND v(dout1_80) AT=525.025n

* CHECK dout1_81 Vdout1_81ck104 = 0.9 time = 525
.meas tran vdout1_81ck104 FIND v(dout1_81) AT=525.025n

* CHECK dout1_82 Vdout1_82ck104 = 0.9 time = 525
.meas tran vdout1_82ck104 FIND v(dout1_82) AT=525.025n

* CHECK dout1_83 Vdout1_83ck104 = 0.9 time = 525
.meas tran vdout1_83ck104 FIND v(dout1_83) AT=525.025n

* CHECK dout1_84 Vdout1_84ck104 = 0 time = 525
.meas tran vdout1_84ck104 FIND v(dout1_84) AT=525.025n

* CHECK dout1_85 Vdout1_85ck104 = 0 time = 525
.meas tran vdout1_85ck104 FIND v(dout1_85) AT=525.025n

* CHECK dout1_86 Vdout1_86ck104 = 0 time = 525
.meas tran vdout1_86ck104 FIND v(dout1_86) AT=525.025n

* CHECK dout1_87 Vdout1_87ck104 = 0 time = 525
.meas tran vdout1_87ck104 FIND v(dout1_87) AT=525.025n

* CHECK dout1_88 Vdout1_88ck104 = 0 time = 525
.meas tran vdout1_88ck104 FIND v(dout1_88) AT=525.025n

* CHECK dout1_89 Vdout1_89ck104 = 0 time = 525
.meas tran vdout1_89ck104 FIND v(dout1_89) AT=525.025n

* CHECK dout1_90 Vdout1_90ck104 = 0.9 time = 525
.meas tran vdout1_90ck104 FIND v(dout1_90) AT=525.025n

* CHECK dout1_91 Vdout1_91ck104 = 0 time = 525
.meas tran vdout1_91ck104 FIND v(dout1_91) AT=525.025n

* CHECK dout1_92 Vdout1_92ck104 = 0 time = 525
.meas tran vdout1_92ck104 FIND v(dout1_92) AT=525.025n

* CHECK dout1_93 Vdout1_93ck104 = 0.9 time = 525
.meas tran vdout1_93ck104 FIND v(dout1_93) AT=525.025n

* CHECK dout1_94 Vdout1_94ck104 = 0 time = 525
.meas tran vdout1_94ck104 FIND v(dout1_94) AT=525.025n

* CHECK dout1_95 Vdout1_95ck104 = 0 time = 525
.meas tran vdout1_95ck104 FIND v(dout1_95) AT=525.025n

* CHECK dout1_96 Vdout1_96ck104 = 0.9 time = 525
.meas tran vdout1_96ck104 FIND v(dout1_96) AT=525.025n

* CHECK dout1_97 Vdout1_97ck104 = 0.9 time = 525
.meas tran vdout1_97ck104 FIND v(dout1_97) AT=525.025n

* CHECK dout1_98 Vdout1_98ck104 = 0 time = 525
.meas tran vdout1_98ck104 FIND v(dout1_98) AT=525.025n

* CHECK dout1_99 Vdout1_99ck104 = 0.9 time = 525
.meas tran vdout1_99ck104 FIND v(dout1_99) AT=525.025n

* CHECK dout1_100 Vdout1_100ck104 = 0.9 time = 525
.meas tran vdout1_100ck104 FIND v(dout1_100) AT=525.025n

* CHECK dout1_101 Vdout1_101ck104 = 0 time = 525
.meas tran vdout1_101ck104 FIND v(dout1_101) AT=525.025n

* CHECK dout1_102 Vdout1_102ck104 = 0 time = 525
.meas tran vdout1_102ck104 FIND v(dout1_102) AT=525.025n

* CHECK dout1_103 Vdout1_103ck104 = 0 time = 525
.meas tran vdout1_103ck104 FIND v(dout1_103) AT=525.025n

* CHECK dout1_104 Vdout1_104ck104 = 0 time = 525
.meas tran vdout1_104ck104 FIND v(dout1_104) AT=525.025n

* CHECK dout1_105 Vdout1_105ck104 = 0 time = 525
.meas tran vdout1_105ck104 FIND v(dout1_105) AT=525.025n

* CHECK dout1_106 Vdout1_106ck104 = 0.9 time = 525
.meas tran vdout1_106ck104 FIND v(dout1_106) AT=525.025n

* CHECK dout1_107 Vdout1_107ck104 = 0 time = 525
.meas tran vdout1_107ck104 FIND v(dout1_107) AT=525.025n

* CHECK dout1_108 Vdout1_108ck104 = 0 time = 525
.meas tran vdout1_108ck104 FIND v(dout1_108) AT=525.025n

* CHECK dout1_109 Vdout1_109ck104 = 0.9 time = 525
.meas tran vdout1_109ck104 FIND v(dout1_109) AT=525.025n

* CHECK dout1_110 Vdout1_110ck104 = 0 time = 525
.meas tran vdout1_110ck104 FIND v(dout1_110) AT=525.025n

* CHECK dout1_111 Vdout1_111ck104 = 0.9 time = 525
.meas tran vdout1_111ck104 FIND v(dout1_111) AT=525.025n

* CHECK dout1_112 Vdout1_112ck104 = 0.9 time = 525
.meas tran vdout1_112ck104 FIND v(dout1_112) AT=525.025n

* CHECK dout1_113 Vdout1_113ck104 = 0 time = 525
.meas tran vdout1_113ck104 FIND v(dout1_113) AT=525.025n

* CHECK dout1_114 Vdout1_114ck104 = 0.9 time = 525
.meas tran vdout1_114ck104 FIND v(dout1_114) AT=525.025n

* CHECK dout1_115 Vdout1_115ck104 = 0 time = 525
.meas tran vdout1_115ck104 FIND v(dout1_115) AT=525.025n

* CHECK dout1_116 Vdout1_116ck104 = 0 time = 525
.meas tran vdout1_116ck104 FIND v(dout1_116) AT=525.025n

* CHECK dout1_117 Vdout1_117ck104 = 0.9 time = 525
.meas tran vdout1_117ck104 FIND v(dout1_117) AT=525.025n

* CHECK dout1_118 Vdout1_118ck104 = 0 time = 525
.meas tran vdout1_118ck104 FIND v(dout1_118) AT=525.025n

* CHECK dout1_119 Vdout1_119ck104 = 0.9 time = 525
.meas tran vdout1_119ck104 FIND v(dout1_119) AT=525.025n

* CHECK dout1_0 Vdout1_0ck105 = 0 time = 530
.meas tran vdout1_0ck105 FIND v(dout1_0) AT=530.025n

* CHECK dout1_1 Vdout1_1ck105 = 0 time = 530
.meas tran vdout1_1ck105 FIND v(dout1_1) AT=530.025n

* CHECK dout1_2 Vdout1_2ck105 = 0 time = 530
.meas tran vdout1_2ck105 FIND v(dout1_2) AT=530.025n

* CHECK dout1_3 Vdout1_3ck105 = 0.9 time = 530
.meas tran vdout1_3ck105 FIND v(dout1_3) AT=530.025n

* CHECK dout1_4 Vdout1_4ck105 = 0.9 time = 530
.meas tran vdout1_4ck105 FIND v(dout1_4) AT=530.025n

* CHECK dout1_5 Vdout1_5ck105 = 0 time = 530
.meas tran vdout1_5ck105 FIND v(dout1_5) AT=530.025n

* CHECK dout1_6 Vdout1_6ck105 = 0 time = 530
.meas tran vdout1_6ck105 FIND v(dout1_6) AT=530.025n

* CHECK dout1_7 Vdout1_7ck105 = 0 time = 530
.meas tran vdout1_7ck105 FIND v(dout1_7) AT=530.025n

* CHECK dout1_8 Vdout1_8ck105 = 0 time = 530
.meas tran vdout1_8ck105 FIND v(dout1_8) AT=530.025n

* CHECK dout1_9 Vdout1_9ck105 = 0.9 time = 530
.meas tran vdout1_9ck105 FIND v(dout1_9) AT=530.025n

* CHECK dout1_10 Vdout1_10ck105 = 0 time = 530
.meas tran vdout1_10ck105 FIND v(dout1_10) AT=530.025n

* CHECK dout1_11 Vdout1_11ck105 = 0.9 time = 530
.meas tran vdout1_11ck105 FIND v(dout1_11) AT=530.025n

* CHECK dout1_12 Vdout1_12ck105 = 0 time = 530
.meas tran vdout1_12ck105 FIND v(dout1_12) AT=530.025n

* CHECK dout1_13 Vdout1_13ck105 = 0 time = 530
.meas tran vdout1_13ck105 FIND v(dout1_13) AT=530.025n

* CHECK dout1_14 Vdout1_14ck105 = 0.9 time = 530
.meas tran vdout1_14ck105 FIND v(dout1_14) AT=530.025n

* CHECK dout1_15 Vdout1_15ck105 = 0 time = 530
.meas tran vdout1_15ck105 FIND v(dout1_15) AT=530.025n

* CHECK dout1_16 Vdout1_16ck105 = 0 time = 530
.meas tran vdout1_16ck105 FIND v(dout1_16) AT=530.025n

* CHECK dout1_17 Vdout1_17ck105 = 0.9 time = 530
.meas tran vdout1_17ck105 FIND v(dout1_17) AT=530.025n

* CHECK dout1_18 Vdout1_18ck105 = 0 time = 530
.meas tran vdout1_18ck105 FIND v(dout1_18) AT=530.025n

* CHECK dout1_19 Vdout1_19ck105 = 0 time = 530
.meas tran vdout1_19ck105 FIND v(dout1_19) AT=530.025n

* CHECK dout1_20 Vdout1_20ck105 = 0 time = 530
.meas tran vdout1_20ck105 FIND v(dout1_20) AT=530.025n

* CHECK dout1_21 Vdout1_21ck105 = 0 time = 530
.meas tran vdout1_21ck105 FIND v(dout1_21) AT=530.025n

* CHECK dout1_22 Vdout1_22ck105 = 0 time = 530
.meas tran vdout1_22ck105 FIND v(dout1_22) AT=530.025n

* CHECK dout1_23 Vdout1_23ck105 = 0.9 time = 530
.meas tran vdout1_23ck105 FIND v(dout1_23) AT=530.025n

* CHECK dout1_24 Vdout1_24ck105 = 0 time = 530
.meas tran vdout1_24ck105 FIND v(dout1_24) AT=530.025n

* CHECK dout1_25 Vdout1_25ck105 = 0.9 time = 530
.meas tran vdout1_25ck105 FIND v(dout1_25) AT=530.025n

* CHECK dout1_26 Vdout1_26ck105 = 0 time = 530
.meas tran vdout1_26ck105 FIND v(dout1_26) AT=530.025n

* CHECK dout1_27 Vdout1_27ck105 = 0 time = 530
.meas tran vdout1_27ck105 FIND v(dout1_27) AT=530.025n

* CHECK dout1_28 Vdout1_28ck105 = 0.9 time = 530
.meas tran vdout1_28ck105 FIND v(dout1_28) AT=530.025n

* CHECK dout1_29 Vdout1_29ck105 = 0.9 time = 530
.meas tran vdout1_29ck105 FIND v(dout1_29) AT=530.025n

* CHECK dout1_30 Vdout1_30ck105 = 0.9 time = 530
.meas tran vdout1_30ck105 FIND v(dout1_30) AT=530.025n

* CHECK dout1_31 Vdout1_31ck105 = 0.9 time = 530
.meas tran vdout1_31ck105 FIND v(dout1_31) AT=530.025n

* CHECK dout1_32 Vdout1_32ck105 = 0.9 time = 530
.meas tran vdout1_32ck105 FIND v(dout1_32) AT=530.025n

* CHECK dout1_33 Vdout1_33ck105 = 0 time = 530
.meas tran vdout1_33ck105 FIND v(dout1_33) AT=530.025n

* CHECK dout1_34 Vdout1_34ck105 = 0.9 time = 530
.meas tran vdout1_34ck105 FIND v(dout1_34) AT=530.025n

* CHECK dout1_35 Vdout1_35ck105 = 0 time = 530
.meas tran vdout1_35ck105 FIND v(dout1_35) AT=530.025n

* CHECK dout1_36 Vdout1_36ck105 = 0.9 time = 530
.meas tran vdout1_36ck105 FIND v(dout1_36) AT=530.025n

* CHECK dout1_37 Vdout1_37ck105 = 0.9 time = 530
.meas tran vdout1_37ck105 FIND v(dout1_37) AT=530.025n

* CHECK dout1_38 Vdout1_38ck105 = 0 time = 530
.meas tran vdout1_38ck105 FIND v(dout1_38) AT=530.025n

* CHECK dout1_39 Vdout1_39ck105 = 0 time = 530
.meas tran vdout1_39ck105 FIND v(dout1_39) AT=530.025n

* CHECK dout1_40 Vdout1_40ck105 = 0.9 time = 530
.meas tran vdout1_40ck105 FIND v(dout1_40) AT=530.025n

* CHECK dout1_41 Vdout1_41ck105 = 0.9 time = 530
.meas tran vdout1_41ck105 FIND v(dout1_41) AT=530.025n

* CHECK dout1_42 Vdout1_42ck105 = 0 time = 530
.meas tran vdout1_42ck105 FIND v(dout1_42) AT=530.025n

* CHECK dout1_43 Vdout1_43ck105 = 0 time = 530
.meas tran vdout1_43ck105 FIND v(dout1_43) AT=530.025n

* CHECK dout1_44 Vdout1_44ck105 = 0 time = 530
.meas tran vdout1_44ck105 FIND v(dout1_44) AT=530.025n

* CHECK dout1_45 Vdout1_45ck105 = 0 time = 530
.meas tran vdout1_45ck105 FIND v(dout1_45) AT=530.025n

* CHECK dout1_46 Vdout1_46ck105 = 0 time = 530
.meas tran vdout1_46ck105 FIND v(dout1_46) AT=530.025n

* CHECK dout1_47 Vdout1_47ck105 = 0 time = 530
.meas tran vdout1_47ck105 FIND v(dout1_47) AT=530.025n

* CHECK dout1_48 Vdout1_48ck105 = 0 time = 530
.meas tran vdout1_48ck105 FIND v(dout1_48) AT=530.025n

* CHECK dout1_49 Vdout1_49ck105 = 0.9 time = 530
.meas tran vdout1_49ck105 FIND v(dout1_49) AT=530.025n

* CHECK dout1_50 Vdout1_50ck105 = 0 time = 530
.meas tran vdout1_50ck105 FIND v(dout1_50) AT=530.025n

* CHECK dout1_51 Vdout1_51ck105 = 0.9 time = 530
.meas tran vdout1_51ck105 FIND v(dout1_51) AT=530.025n

* CHECK dout1_52 Vdout1_52ck105 = 0.9 time = 530
.meas tran vdout1_52ck105 FIND v(dout1_52) AT=530.025n

* CHECK dout1_53 Vdout1_53ck105 = 0.9 time = 530
.meas tran vdout1_53ck105 FIND v(dout1_53) AT=530.025n

* CHECK dout1_54 Vdout1_54ck105 = 0.9 time = 530
.meas tran vdout1_54ck105 FIND v(dout1_54) AT=530.025n

* CHECK dout1_55 Vdout1_55ck105 = 0 time = 530
.meas tran vdout1_55ck105 FIND v(dout1_55) AT=530.025n

* CHECK dout1_56 Vdout1_56ck105 = 0.9 time = 530
.meas tran vdout1_56ck105 FIND v(dout1_56) AT=530.025n

* CHECK dout1_57 Vdout1_57ck105 = 0.9 time = 530
.meas tran vdout1_57ck105 FIND v(dout1_57) AT=530.025n

* CHECK dout1_58 Vdout1_58ck105 = 0 time = 530
.meas tran vdout1_58ck105 FIND v(dout1_58) AT=530.025n

* CHECK dout1_59 Vdout1_59ck105 = 0.9 time = 530
.meas tran vdout1_59ck105 FIND v(dout1_59) AT=530.025n

* CHECK dout1_60 Vdout1_60ck105 = 0 time = 530
.meas tran vdout1_60ck105 FIND v(dout1_60) AT=530.025n

* CHECK dout1_61 Vdout1_61ck105 = 0.9 time = 530
.meas tran vdout1_61ck105 FIND v(dout1_61) AT=530.025n

* CHECK dout1_62 Vdout1_62ck105 = 0 time = 530
.meas tran vdout1_62ck105 FIND v(dout1_62) AT=530.025n

* CHECK dout1_63 Vdout1_63ck105 = 0.9 time = 530
.meas tran vdout1_63ck105 FIND v(dout1_63) AT=530.025n

* CHECK dout1_64 Vdout1_64ck105 = 0.9 time = 530
.meas tran vdout1_64ck105 FIND v(dout1_64) AT=530.025n

* CHECK dout1_65 Vdout1_65ck105 = 0.9 time = 530
.meas tran vdout1_65ck105 FIND v(dout1_65) AT=530.025n

* CHECK dout1_66 Vdout1_66ck105 = 0.9 time = 530
.meas tran vdout1_66ck105 FIND v(dout1_66) AT=530.025n

* CHECK dout1_67 Vdout1_67ck105 = 0.9 time = 530
.meas tran vdout1_67ck105 FIND v(dout1_67) AT=530.025n

* CHECK dout1_68 Vdout1_68ck105 = 0.9 time = 530
.meas tran vdout1_68ck105 FIND v(dout1_68) AT=530.025n

* CHECK dout1_69 Vdout1_69ck105 = 0 time = 530
.meas tran vdout1_69ck105 FIND v(dout1_69) AT=530.025n

* CHECK dout1_70 Vdout1_70ck105 = 0.9 time = 530
.meas tran vdout1_70ck105 FIND v(dout1_70) AT=530.025n

* CHECK dout1_71 Vdout1_71ck105 = 0.9 time = 530
.meas tran vdout1_71ck105 FIND v(dout1_71) AT=530.025n

* CHECK dout1_72 Vdout1_72ck105 = 0.9 time = 530
.meas tran vdout1_72ck105 FIND v(dout1_72) AT=530.025n

* CHECK dout1_73 Vdout1_73ck105 = 0 time = 530
.meas tran vdout1_73ck105 FIND v(dout1_73) AT=530.025n

* CHECK dout1_74 Vdout1_74ck105 = 0 time = 530
.meas tran vdout1_74ck105 FIND v(dout1_74) AT=530.025n

* CHECK dout1_75 Vdout1_75ck105 = 0.9 time = 530
.meas tran vdout1_75ck105 FIND v(dout1_75) AT=530.025n

* CHECK dout1_76 Vdout1_76ck105 = 0 time = 530
.meas tran vdout1_76ck105 FIND v(dout1_76) AT=530.025n

* CHECK dout1_77 Vdout1_77ck105 = 0.9 time = 530
.meas tran vdout1_77ck105 FIND v(dout1_77) AT=530.025n

* CHECK dout1_78 Vdout1_78ck105 = 0.9 time = 530
.meas tran vdout1_78ck105 FIND v(dout1_78) AT=530.025n

* CHECK dout1_79 Vdout1_79ck105 = 0 time = 530
.meas tran vdout1_79ck105 FIND v(dout1_79) AT=530.025n

* CHECK dout1_80 Vdout1_80ck105 = 0 time = 530
.meas tran vdout1_80ck105 FIND v(dout1_80) AT=530.025n

* CHECK dout1_81 Vdout1_81ck105 = 0 time = 530
.meas tran vdout1_81ck105 FIND v(dout1_81) AT=530.025n

* CHECK dout1_82 Vdout1_82ck105 = 0 time = 530
.meas tran vdout1_82ck105 FIND v(dout1_82) AT=530.025n

* CHECK dout1_83 Vdout1_83ck105 = 0 time = 530
.meas tran vdout1_83ck105 FIND v(dout1_83) AT=530.025n

* CHECK dout1_84 Vdout1_84ck105 = 0 time = 530
.meas tran vdout1_84ck105 FIND v(dout1_84) AT=530.025n

* CHECK dout1_85 Vdout1_85ck105 = 0.9 time = 530
.meas tran vdout1_85ck105 FIND v(dout1_85) AT=530.025n

* CHECK dout1_86 Vdout1_86ck105 = 0.9 time = 530
.meas tran vdout1_86ck105 FIND v(dout1_86) AT=530.025n

* CHECK dout1_87 Vdout1_87ck105 = 0.9 time = 530
.meas tran vdout1_87ck105 FIND v(dout1_87) AT=530.025n

* CHECK dout1_88 Vdout1_88ck105 = 0 time = 530
.meas tran vdout1_88ck105 FIND v(dout1_88) AT=530.025n

* CHECK dout1_89 Vdout1_89ck105 = 0 time = 530
.meas tran vdout1_89ck105 FIND v(dout1_89) AT=530.025n

* CHECK dout1_90 Vdout1_90ck105 = 0.9 time = 530
.meas tran vdout1_90ck105 FIND v(dout1_90) AT=530.025n

* CHECK dout1_91 Vdout1_91ck105 = 0.9 time = 530
.meas tran vdout1_91ck105 FIND v(dout1_91) AT=530.025n

* CHECK dout1_92 Vdout1_92ck105 = 0 time = 530
.meas tran vdout1_92ck105 FIND v(dout1_92) AT=530.025n

* CHECK dout1_93 Vdout1_93ck105 = 0.9 time = 530
.meas tran vdout1_93ck105 FIND v(dout1_93) AT=530.025n

* CHECK dout1_94 Vdout1_94ck105 = 0.9 time = 530
.meas tran vdout1_94ck105 FIND v(dout1_94) AT=530.025n

* CHECK dout1_95 Vdout1_95ck105 = 0.9 time = 530
.meas tran vdout1_95ck105 FIND v(dout1_95) AT=530.025n

* CHECK dout1_96 Vdout1_96ck105 = 0 time = 530
.meas tran vdout1_96ck105 FIND v(dout1_96) AT=530.025n

* CHECK dout1_97 Vdout1_97ck105 = 0 time = 530
.meas tran vdout1_97ck105 FIND v(dout1_97) AT=530.025n

* CHECK dout1_98 Vdout1_98ck105 = 0 time = 530
.meas tran vdout1_98ck105 FIND v(dout1_98) AT=530.025n

* CHECK dout1_99 Vdout1_99ck105 = 0.9 time = 530
.meas tran vdout1_99ck105 FIND v(dout1_99) AT=530.025n

* CHECK dout1_100 Vdout1_100ck105 = 0 time = 530
.meas tran vdout1_100ck105 FIND v(dout1_100) AT=530.025n

* CHECK dout1_101 Vdout1_101ck105 = 0.9 time = 530
.meas tran vdout1_101ck105 FIND v(dout1_101) AT=530.025n

* CHECK dout1_102 Vdout1_102ck105 = 0.9 time = 530
.meas tran vdout1_102ck105 FIND v(dout1_102) AT=530.025n

* CHECK dout1_103 Vdout1_103ck105 = 0 time = 530
.meas tran vdout1_103ck105 FIND v(dout1_103) AT=530.025n

* CHECK dout1_104 Vdout1_104ck105 = 0 time = 530
.meas tran vdout1_104ck105 FIND v(dout1_104) AT=530.025n

* CHECK dout1_105 Vdout1_105ck105 = 0 time = 530
.meas tran vdout1_105ck105 FIND v(dout1_105) AT=530.025n

* CHECK dout1_106 Vdout1_106ck105 = 0 time = 530
.meas tran vdout1_106ck105 FIND v(dout1_106) AT=530.025n

* CHECK dout1_107 Vdout1_107ck105 = 0 time = 530
.meas tran vdout1_107ck105 FIND v(dout1_107) AT=530.025n

* CHECK dout1_108 Vdout1_108ck105 = 0 time = 530
.meas tran vdout1_108ck105 FIND v(dout1_108) AT=530.025n

* CHECK dout1_109 Vdout1_109ck105 = 0.9 time = 530
.meas tran vdout1_109ck105 FIND v(dout1_109) AT=530.025n

* CHECK dout1_110 Vdout1_110ck105 = 0 time = 530
.meas tran vdout1_110ck105 FIND v(dout1_110) AT=530.025n

* CHECK dout1_111 Vdout1_111ck105 = 0.9 time = 530
.meas tran vdout1_111ck105 FIND v(dout1_111) AT=530.025n

* CHECK dout1_112 Vdout1_112ck105 = 0.9 time = 530
.meas tran vdout1_112ck105 FIND v(dout1_112) AT=530.025n

* CHECK dout1_113 Vdout1_113ck105 = 0.9 time = 530
.meas tran vdout1_113ck105 FIND v(dout1_113) AT=530.025n

* CHECK dout1_114 Vdout1_114ck105 = 0 time = 530
.meas tran vdout1_114ck105 FIND v(dout1_114) AT=530.025n

* CHECK dout1_115 Vdout1_115ck105 = 0.9 time = 530
.meas tran vdout1_115ck105 FIND v(dout1_115) AT=530.025n

* CHECK dout1_116 Vdout1_116ck105 = 0 time = 530
.meas tran vdout1_116ck105 FIND v(dout1_116) AT=530.025n

* CHECK dout1_117 Vdout1_117ck105 = 0.9 time = 530
.meas tran vdout1_117ck105 FIND v(dout1_117) AT=530.025n

* CHECK dout1_118 Vdout1_118ck105 = 0 time = 530
.meas tran vdout1_118ck105 FIND v(dout1_118) AT=530.025n

* CHECK dout1_119 Vdout1_119ck105 = 0 time = 530
.meas tran vdout1_119ck105 FIND v(dout1_119) AT=530.025n

* CHECK dout1_0 Vdout1_0ck106 = 0 time = 535
.meas tran vdout1_0ck106 FIND v(dout1_0) AT=535.025n

* CHECK dout1_1 Vdout1_1ck106 = 0.9 time = 535
.meas tran vdout1_1ck106 FIND v(dout1_1) AT=535.025n

* CHECK dout1_2 Vdout1_2ck106 = 0 time = 535
.meas tran vdout1_2ck106 FIND v(dout1_2) AT=535.025n

* CHECK dout1_3 Vdout1_3ck106 = 0 time = 535
.meas tran vdout1_3ck106 FIND v(dout1_3) AT=535.025n

* CHECK dout1_4 Vdout1_4ck106 = 0 time = 535
.meas tran vdout1_4ck106 FIND v(dout1_4) AT=535.025n

* CHECK dout1_5 Vdout1_5ck106 = 0 time = 535
.meas tran vdout1_5ck106 FIND v(dout1_5) AT=535.025n

* CHECK dout1_6 Vdout1_6ck106 = 0.9 time = 535
.meas tran vdout1_6ck106 FIND v(dout1_6) AT=535.025n

* CHECK dout1_7 Vdout1_7ck106 = 0 time = 535
.meas tran vdout1_7ck106 FIND v(dout1_7) AT=535.025n

* CHECK dout1_8 Vdout1_8ck106 = 0 time = 535
.meas tran vdout1_8ck106 FIND v(dout1_8) AT=535.025n

* CHECK dout1_9 Vdout1_9ck106 = 0 time = 535
.meas tran vdout1_9ck106 FIND v(dout1_9) AT=535.025n

* CHECK dout1_10 Vdout1_10ck106 = 0 time = 535
.meas tran vdout1_10ck106 FIND v(dout1_10) AT=535.025n

* CHECK dout1_11 Vdout1_11ck106 = 0.9 time = 535
.meas tran vdout1_11ck106 FIND v(dout1_11) AT=535.025n

* CHECK dout1_12 Vdout1_12ck106 = 0.9 time = 535
.meas tran vdout1_12ck106 FIND v(dout1_12) AT=535.025n

* CHECK dout1_13 Vdout1_13ck106 = 0.9 time = 535
.meas tran vdout1_13ck106 FIND v(dout1_13) AT=535.025n

* CHECK dout1_14 Vdout1_14ck106 = 0 time = 535
.meas tran vdout1_14ck106 FIND v(dout1_14) AT=535.025n

* CHECK dout1_15 Vdout1_15ck106 = 0.9 time = 535
.meas tran vdout1_15ck106 FIND v(dout1_15) AT=535.025n

* CHECK dout1_16 Vdout1_16ck106 = 0 time = 535
.meas tran vdout1_16ck106 FIND v(dout1_16) AT=535.025n

* CHECK dout1_17 Vdout1_17ck106 = 0 time = 535
.meas tran vdout1_17ck106 FIND v(dout1_17) AT=535.025n

* CHECK dout1_18 Vdout1_18ck106 = 0.9 time = 535
.meas tran vdout1_18ck106 FIND v(dout1_18) AT=535.025n

* CHECK dout1_19 Vdout1_19ck106 = 0.9 time = 535
.meas tran vdout1_19ck106 FIND v(dout1_19) AT=535.025n

* CHECK dout1_20 Vdout1_20ck106 = 0.9 time = 535
.meas tran vdout1_20ck106 FIND v(dout1_20) AT=535.025n

* CHECK dout1_21 Vdout1_21ck106 = 0.9 time = 535
.meas tran vdout1_21ck106 FIND v(dout1_21) AT=535.025n

* CHECK dout1_22 Vdout1_22ck106 = 0.9 time = 535
.meas tran vdout1_22ck106 FIND v(dout1_22) AT=535.025n

* CHECK dout1_23 Vdout1_23ck106 = 0 time = 535
.meas tran vdout1_23ck106 FIND v(dout1_23) AT=535.025n

* CHECK dout1_24 Vdout1_24ck106 = 0 time = 535
.meas tran vdout1_24ck106 FIND v(dout1_24) AT=535.025n

* CHECK dout1_25 Vdout1_25ck106 = 0.9 time = 535
.meas tran vdout1_25ck106 FIND v(dout1_25) AT=535.025n

* CHECK dout1_26 Vdout1_26ck106 = 0.9 time = 535
.meas tran vdout1_26ck106 FIND v(dout1_26) AT=535.025n

* CHECK dout1_27 Vdout1_27ck106 = 0 time = 535
.meas tran vdout1_27ck106 FIND v(dout1_27) AT=535.025n

* CHECK dout1_28 Vdout1_28ck106 = 0 time = 535
.meas tran vdout1_28ck106 FIND v(dout1_28) AT=535.025n

* CHECK dout1_29 Vdout1_29ck106 = 0 time = 535
.meas tran vdout1_29ck106 FIND v(dout1_29) AT=535.025n

* CHECK dout1_30 Vdout1_30ck106 = 0 time = 535
.meas tran vdout1_30ck106 FIND v(dout1_30) AT=535.025n

* CHECK dout1_31 Vdout1_31ck106 = 0.9 time = 535
.meas tran vdout1_31ck106 FIND v(dout1_31) AT=535.025n

* CHECK dout1_32 Vdout1_32ck106 = 0 time = 535
.meas tran vdout1_32ck106 FIND v(dout1_32) AT=535.025n

* CHECK dout1_33 Vdout1_33ck106 = 0.9 time = 535
.meas tran vdout1_33ck106 FIND v(dout1_33) AT=535.025n

* CHECK dout1_34 Vdout1_34ck106 = 0.9 time = 535
.meas tran vdout1_34ck106 FIND v(dout1_34) AT=535.025n

* CHECK dout1_35 Vdout1_35ck106 = 0 time = 535
.meas tran vdout1_35ck106 FIND v(dout1_35) AT=535.025n

* CHECK dout1_36 Vdout1_36ck106 = 0.9 time = 535
.meas tran vdout1_36ck106 FIND v(dout1_36) AT=535.025n

* CHECK dout1_37 Vdout1_37ck106 = 0.9 time = 535
.meas tran vdout1_37ck106 FIND v(dout1_37) AT=535.025n

* CHECK dout1_38 Vdout1_38ck106 = 0.9 time = 535
.meas tran vdout1_38ck106 FIND v(dout1_38) AT=535.025n

* CHECK dout1_39 Vdout1_39ck106 = 0 time = 535
.meas tran vdout1_39ck106 FIND v(dout1_39) AT=535.025n

* CHECK dout1_40 Vdout1_40ck106 = 0.9 time = 535
.meas tran vdout1_40ck106 FIND v(dout1_40) AT=535.025n

* CHECK dout1_41 Vdout1_41ck106 = 0.9 time = 535
.meas tran vdout1_41ck106 FIND v(dout1_41) AT=535.025n

* CHECK dout1_42 Vdout1_42ck106 = 0.9 time = 535
.meas tran vdout1_42ck106 FIND v(dout1_42) AT=535.025n

* CHECK dout1_43 Vdout1_43ck106 = 0.9 time = 535
.meas tran vdout1_43ck106 FIND v(dout1_43) AT=535.025n

* CHECK dout1_44 Vdout1_44ck106 = 0.9 time = 535
.meas tran vdout1_44ck106 FIND v(dout1_44) AT=535.025n

* CHECK dout1_45 Vdout1_45ck106 = 0.9 time = 535
.meas tran vdout1_45ck106 FIND v(dout1_45) AT=535.025n

* CHECK dout1_46 Vdout1_46ck106 = 0.9 time = 535
.meas tran vdout1_46ck106 FIND v(dout1_46) AT=535.025n

* CHECK dout1_47 Vdout1_47ck106 = 0.9 time = 535
.meas tran vdout1_47ck106 FIND v(dout1_47) AT=535.025n

* CHECK dout1_48 Vdout1_48ck106 = 0.9 time = 535
.meas tran vdout1_48ck106 FIND v(dout1_48) AT=535.025n

* CHECK dout1_49 Vdout1_49ck106 = 0 time = 535
.meas tran vdout1_49ck106 FIND v(dout1_49) AT=535.025n

* CHECK dout1_50 Vdout1_50ck106 = 0.9 time = 535
.meas tran vdout1_50ck106 FIND v(dout1_50) AT=535.025n

* CHECK dout1_51 Vdout1_51ck106 = 0 time = 535
.meas tran vdout1_51ck106 FIND v(dout1_51) AT=535.025n

* CHECK dout1_52 Vdout1_52ck106 = 0.9 time = 535
.meas tran vdout1_52ck106 FIND v(dout1_52) AT=535.025n

* CHECK dout1_53 Vdout1_53ck106 = 0 time = 535
.meas tran vdout1_53ck106 FIND v(dout1_53) AT=535.025n

* CHECK dout1_54 Vdout1_54ck106 = 0.9 time = 535
.meas tran vdout1_54ck106 FIND v(dout1_54) AT=535.025n

* CHECK dout1_55 Vdout1_55ck106 = 0.9 time = 535
.meas tran vdout1_55ck106 FIND v(dout1_55) AT=535.025n

* CHECK dout1_56 Vdout1_56ck106 = 0.9 time = 535
.meas tran vdout1_56ck106 FIND v(dout1_56) AT=535.025n

* CHECK dout1_57 Vdout1_57ck106 = 0 time = 535
.meas tran vdout1_57ck106 FIND v(dout1_57) AT=535.025n

* CHECK dout1_58 Vdout1_58ck106 = 0.9 time = 535
.meas tran vdout1_58ck106 FIND v(dout1_58) AT=535.025n

* CHECK dout1_59 Vdout1_59ck106 = 0 time = 535
.meas tran vdout1_59ck106 FIND v(dout1_59) AT=535.025n

* CHECK dout1_60 Vdout1_60ck106 = 0 time = 535
.meas tran vdout1_60ck106 FIND v(dout1_60) AT=535.025n

* CHECK dout1_61 Vdout1_61ck106 = 0.9 time = 535
.meas tran vdout1_61ck106 FIND v(dout1_61) AT=535.025n

* CHECK dout1_62 Vdout1_62ck106 = 0.9 time = 535
.meas tran vdout1_62ck106 FIND v(dout1_62) AT=535.025n

* CHECK dout1_63 Vdout1_63ck106 = 0 time = 535
.meas tran vdout1_63ck106 FIND v(dout1_63) AT=535.025n

* CHECK dout1_64 Vdout1_64ck106 = 0.9 time = 535
.meas tran vdout1_64ck106 FIND v(dout1_64) AT=535.025n

* CHECK dout1_65 Vdout1_65ck106 = 0 time = 535
.meas tran vdout1_65ck106 FIND v(dout1_65) AT=535.025n

* CHECK dout1_66 Vdout1_66ck106 = 0 time = 535
.meas tran vdout1_66ck106 FIND v(dout1_66) AT=535.025n

* CHECK dout1_67 Vdout1_67ck106 = 0 time = 535
.meas tran vdout1_67ck106 FIND v(dout1_67) AT=535.025n

* CHECK dout1_68 Vdout1_68ck106 = 0.9 time = 535
.meas tran vdout1_68ck106 FIND v(dout1_68) AT=535.025n

* CHECK dout1_69 Vdout1_69ck106 = 0 time = 535
.meas tran vdout1_69ck106 FIND v(dout1_69) AT=535.025n

* CHECK dout1_70 Vdout1_70ck106 = 0.9 time = 535
.meas tran vdout1_70ck106 FIND v(dout1_70) AT=535.025n

* CHECK dout1_71 Vdout1_71ck106 = 0.9 time = 535
.meas tran vdout1_71ck106 FIND v(dout1_71) AT=535.025n

* CHECK dout1_72 Vdout1_72ck106 = 0 time = 535
.meas tran vdout1_72ck106 FIND v(dout1_72) AT=535.025n

* CHECK dout1_73 Vdout1_73ck106 = 0.9 time = 535
.meas tran vdout1_73ck106 FIND v(dout1_73) AT=535.025n

* CHECK dout1_74 Vdout1_74ck106 = 0 time = 535
.meas tran vdout1_74ck106 FIND v(dout1_74) AT=535.025n

* CHECK dout1_75 Vdout1_75ck106 = 0.9 time = 535
.meas tran vdout1_75ck106 FIND v(dout1_75) AT=535.025n

* CHECK dout1_76 Vdout1_76ck106 = 0 time = 535
.meas tran vdout1_76ck106 FIND v(dout1_76) AT=535.025n

* CHECK dout1_77 Vdout1_77ck106 = 0 time = 535
.meas tran vdout1_77ck106 FIND v(dout1_77) AT=535.025n

* CHECK dout1_78 Vdout1_78ck106 = 0 time = 535
.meas tran vdout1_78ck106 FIND v(dout1_78) AT=535.025n

* CHECK dout1_79 Vdout1_79ck106 = 0.9 time = 535
.meas tran vdout1_79ck106 FIND v(dout1_79) AT=535.025n

* CHECK dout1_80 Vdout1_80ck106 = 0 time = 535
.meas tran vdout1_80ck106 FIND v(dout1_80) AT=535.025n

* CHECK dout1_81 Vdout1_81ck106 = 0.9 time = 535
.meas tran vdout1_81ck106 FIND v(dout1_81) AT=535.025n

* CHECK dout1_82 Vdout1_82ck106 = 0.9 time = 535
.meas tran vdout1_82ck106 FIND v(dout1_82) AT=535.025n

* CHECK dout1_83 Vdout1_83ck106 = 0.9 time = 535
.meas tran vdout1_83ck106 FIND v(dout1_83) AT=535.025n

* CHECK dout1_84 Vdout1_84ck106 = 0 time = 535
.meas tran vdout1_84ck106 FIND v(dout1_84) AT=535.025n

* CHECK dout1_85 Vdout1_85ck106 = 0 time = 535
.meas tran vdout1_85ck106 FIND v(dout1_85) AT=535.025n

* CHECK dout1_86 Vdout1_86ck106 = 0 time = 535
.meas tran vdout1_86ck106 FIND v(dout1_86) AT=535.025n

* CHECK dout1_87 Vdout1_87ck106 = 0 time = 535
.meas tran vdout1_87ck106 FIND v(dout1_87) AT=535.025n

* CHECK dout1_88 Vdout1_88ck106 = 0 time = 535
.meas tran vdout1_88ck106 FIND v(dout1_88) AT=535.025n

* CHECK dout1_89 Vdout1_89ck106 = 0 time = 535
.meas tran vdout1_89ck106 FIND v(dout1_89) AT=535.025n

* CHECK dout1_90 Vdout1_90ck106 = 0.9 time = 535
.meas tran vdout1_90ck106 FIND v(dout1_90) AT=535.025n

* CHECK dout1_91 Vdout1_91ck106 = 0 time = 535
.meas tran vdout1_91ck106 FIND v(dout1_91) AT=535.025n

* CHECK dout1_92 Vdout1_92ck106 = 0 time = 535
.meas tran vdout1_92ck106 FIND v(dout1_92) AT=535.025n

* CHECK dout1_93 Vdout1_93ck106 = 0.9 time = 535
.meas tran vdout1_93ck106 FIND v(dout1_93) AT=535.025n

* CHECK dout1_94 Vdout1_94ck106 = 0 time = 535
.meas tran vdout1_94ck106 FIND v(dout1_94) AT=535.025n

* CHECK dout1_95 Vdout1_95ck106 = 0 time = 535
.meas tran vdout1_95ck106 FIND v(dout1_95) AT=535.025n

* CHECK dout1_96 Vdout1_96ck106 = 0.9 time = 535
.meas tran vdout1_96ck106 FIND v(dout1_96) AT=535.025n

* CHECK dout1_97 Vdout1_97ck106 = 0.9 time = 535
.meas tran vdout1_97ck106 FIND v(dout1_97) AT=535.025n

* CHECK dout1_98 Vdout1_98ck106 = 0 time = 535
.meas tran vdout1_98ck106 FIND v(dout1_98) AT=535.025n

* CHECK dout1_99 Vdout1_99ck106 = 0.9 time = 535
.meas tran vdout1_99ck106 FIND v(dout1_99) AT=535.025n

* CHECK dout1_100 Vdout1_100ck106 = 0.9 time = 535
.meas tran vdout1_100ck106 FIND v(dout1_100) AT=535.025n

* CHECK dout1_101 Vdout1_101ck106 = 0 time = 535
.meas tran vdout1_101ck106 FIND v(dout1_101) AT=535.025n

* CHECK dout1_102 Vdout1_102ck106 = 0 time = 535
.meas tran vdout1_102ck106 FIND v(dout1_102) AT=535.025n

* CHECK dout1_103 Vdout1_103ck106 = 0 time = 535
.meas tran vdout1_103ck106 FIND v(dout1_103) AT=535.025n

* CHECK dout1_104 Vdout1_104ck106 = 0 time = 535
.meas tran vdout1_104ck106 FIND v(dout1_104) AT=535.025n

* CHECK dout1_105 Vdout1_105ck106 = 0 time = 535
.meas tran vdout1_105ck106 FIND v(dout1_105) AT=535.025n

* CHECK dout1_106 Vdout1_106ck106 = 0.9 time = 535
.meas tran vdout1_106ck106 FIND v(dout1_106) AT=535.025n

* CHECK dout1_107 Vdout1_107ck106 = 0 time = 535
.meas tran vdout1_107ck106 FIND v(dout1_107) AT=535.025n

* CHECK dout1_108 Vdout1_108ck106 = 0 time = 535
.meas tran vdout1_108ck106 FIND v(dout1_108) AT=535.025n

* CHECK dout1_109 Vdout1_109ck106 = 0.9 time = 535
.meas tran vdout1_109ck106 FIND v(dout1_109) AT=535.025n

* CHECK dout1_110 Vdout1_110ck106 = 0 time = 535
.meas tran vdout1_110ck106 FIND v(dout1_110) AT=535.025n

* CHECK dout1_111 Vdout1_111ck106 = 0.9 time = 535
.meas tran vdout1_111ck106 FIND v(dout1_111) AT=535.025n

* CHECK dout1_112 Vdout1_112ck106 = 0.9 time = 535
.meas tran vdout1_112ck106 FIND v(dout1_112) AT=535.025n

* CHECK dout1_113 Vdout1_113ck106 = 0 time = 535
.meas tran vdout1_113ck106 FIND v(dout1_113) AT=535.025n

* CHECK dout1_114 Vdout1_114ck106 = 0.9 time = 535
.meas tran vdout1_114ck106 FIND v(dout1_114) AT=535.025n

* CHECK dout1_115 Vdout1_115ck106 = 0 time = 535
.meas tran vdout1_115ck106 FIND v(dout1_115) AT=535.025n

* CHECK dout1_116 Vdout1_116ck106 = 0 time = 535
.meas tran vdout1_116ck106 FIND v(dout1_116) AT=535.025n

* CHECK dout1_117 Vdout1_117ck106 = 0.9 time = 535
.meas tran vdout1_117ck106 FIND v(dout1_117) AT=535.025n

* CHECK dout1_118 Vdout1_118ck106 = 0 time = 535
.meas tran vdout1_118ck106 FIND v(dout1_118) AT=535.025n

* CHECK dout1_119 Vdout1_119ck106 = 0.9 time = 535
.meas tran vdout1_119ck106 FIND v(dout1_119) AT=535.025n

* CHECK dout1_0 Vdout1_0ck107 = 0 time = 540
.meas tran vdout1_0ck107 FIND v(dout1_0) AT=540.025n

* CHECK dout1_1 Vdout1_1ck107 = 0.9 time = 540
.meas tran vdout1_1ck107 FIND v(dout1_1) AT=540.025n

* CHECK dout1_2 Vdout1_2ck107 = 0 time = 540
.meas tran vdout1_2ck107 FIND v(dout1_2) AT=540.025n

* CHECK dout1_3 Vdout1_3ck107 = 0 time = 540
.meas tran vdout1_3ck107 FIND v(dout1_3) AT=540.025n

* CHECK dout1_4 Vdout1_4ck107 = 0 time = 540
.meas tran vdout1_4ck107 FIND v(dout1_4) AT=540.025n

* CHECK dout1_5 Vdout1_5ck107 = 0 time = 540
.meas tran vdout1_5ck107 FIND v(dout1_5) AT=540.025n

* CHECK dout1_6 Vdout1_6ck107 = 0.9 time = 540
.meas tran vdout1_6ck107 FIND v(dout1_6) AT=540.025n

* CHECK dout1_7 Vdout1_7ck107 = 0 time = 540
.meas tran vdout1_7ck107 FIND v(dout1_7) AT=540.025n

* CHECK dout1_8 Vdout1_8ck107 = 0 time = 540
.meas tran vdout1_8ck107 FIND v(dout1_8) AT=540.025n

* CHECK dout1_9 Vdout1_9ck107 = 0 time = 540
.meas tran vdout1_9ck107 FIND v(dout1_9) AT=540.025n

* CHECK dout1_10 Vdout1_10ck107 = 0 time = 540
.meas tran vdout1_10ck107 FIND v(dout1_10) AT=540.025n

* CHECK dout1_11 Vdout1_11ck107 = 0.9 time = 540
.meas tran vdout1_11ck107 FIND v(dout1_11) AT=540.025n

* CHECK dout1_12 Vdout1_12ck107 = 0.9 time = 540
.meas tran vdout1_12ck107 FIND v(dout1_12) AT=540.025n

* CHECK dout1_13 Vdout1_13ck107 = 0.9 time = 540
.meas tran vdout1_13ck107 FIND v(dout1_13) AT=540.025n

* CHECK dout1_14 Vdout1_14ck107 = 0 time = 540
.meas tran vdout1_14ck107 FIND v(dout1_14) AT=540.025n

* CHECK dout1_15 Vdout1_15ck107 = 0.9 time = 540
.meas tran vdout1_15ck107 FIND v(dout1_15) AT=540.025n

* CHECK dout1_16 Vdout1_16ck107 = 0 time = 540
.meas tran vdout1_16ck107 FIND v(dout1_16) AT=540.025n

* CHECK dout1_17 Vdout1_17ck107 = 0 time = 540
.meas tran vdout1_17ck107 FIND v(dout1_17) AT=540.025n

* CHECK dout1_18 Vdout1_18ck107 = 0.9 time = 540
.meas tran vdout1_18ck107 FIND v(dout1_18) AT=540.025n

* CHECK dout1_19 Vdout1_19ck107 = 0.9 time = 540
.meas tran vdout1_19ck107 FIND v(dout1_19) AT=540.025n

* CHECK dout1_20 Vdout1_20ck107 = 0.9 time = 540
.meas tran vdout1_20ck107 FIND v(dout1_20) AT=540.025n

* CHECK dout1_21 Vdout1_21ck107 = 0.9 time = 540
.meas tran vdout1_21ck107 FIND v(dout1_21) AT=540.025n

* CHECK dout1_22 Vdout1_22ck107 = 0.9 time = 540
.meas tran vdout1_22ck107 FIND v(dout1_22) AT=540.025n

* CHECK dout1_23 Vdout1_23ck107 = 0 time = 540
.meas tran vdout1_23ck107 FIND v(dout1_23) AT=540.025n

* CHECK dout1_24 Vdout1_24ck107 = 0 time = 540
.meas tran vdout1_24ck107 FIND v(dout1_24) AT=540.025n

* CHECK dout1_25 Vdout1_25ck107 = 0.9 time = 540
.meas tran vdout1_25ck107 FIND v(dout1_25) AT=540.025n

* CHECK dout1_26 Vdout1_26ck107 = 0.9 time = 540
.meas tran vdout1_26ck107 FIND v(dout1_26) AT=540.025n

* CHECK dout1_27 Vdout1_27ck107 = 0 time = 540
.meas tran vdout1_27ck107 FIND v(dout1_27) AT=540.025n

* CHECK dout1_28 Vdout1_28ck107 = 0 time = 540
.meas tran vdout1_28ck107 FIND v(dout1_28) AT=540.025n

* CHECK dout1_29 Vdout1_29ck107 = 0 time = 540
.meas tran vdout1_29ck107 FIND v(dout1_29) AT=540.025n

* CHECK dout1_30 Vdout1_30ck107 = 0 time = 540
.meas tran vdout1_30ck107 FIND v(dout1_30) AT=540.025n

* CHECK dout1_31 Vdout1_31ck107 = 0.9 time = 540
.meas tran vdout1_31ck107 FIND v(dout1_31) AT=540.025n

* CHECK dout1_32 Vdout1_32ck107 = 0 time = 540
.meas tran vdout1_32ck107 FIND v(dout1_32) AT=540.025n

* CHECK dout1_33 Vdout1_33ck107 = 0.9 time = 540
.meas tran vdout1_33ck107 FIND v(dout1_33) AT=540.025n

* CHECK dout1_34 Vdout1_34ck107 = 0.9 time = 540
.meas tran vdout1_34ck107 FIND v(dout1_34) AT=540.025n

* CHECK dout1_35 Vdout1_35ck107 = 0 time = 540
.meas tran vdout1_35ck107 FIND v(dout1_35) AT=540.025n

* CHECK dout1_36 Vdout1_36ck107 = 0.9 time = 540
.meas tran vdout1_36ck107 FIND v(dout1_36) AT=540.025n

* CHECK dout1_37 Vdout1_37ck107 = 0.9 time = 540
.meas tran vdout1_37ck107 FIND v(dout1_37) AT=540.025n

* CHECK dout1_38 Vdout1_38ck107 = 0.9 time = 540
.meas tran vdout1_38ck107 FIND v(dout1_38) AT=540.025n

* CHECK dout1_39 Vdout1_39ck107 = 0 time = 540
.meas tran vdout1_39ck107 FIND v(dout1_39) AT=540.025n

* CHECK dout1_40 Vdout1_40ck107 = 0.9 time = 540
.meas tran vdout1_40ck107 FIND v(dout1_40) AT=540.025n

* CHECK dout1_41 Vdout1_41ck107 = 0.9 time = 540
.meas tran vdout1_41ck107 FIND v(dout1_41) AT=540.025n

* CHECK dout1_42 Vdout1_42ck107 = 0.9 time = 540
.meas tran vdout1_42ck107 FIND v(dout1_42) AT=540.025n

* CHECK dout1_43 Vdout1_43ck107 = 0.9 time = 540
.meas tran vdout1_43ck107 FIND v(dout1_43) AT=540.025n

* CHECK dout1_44 Vdout1_44ck107 = 0.9 time = 540
.meas tran vdout1_44ck107 FIND v(dout1_44) AT=540.025n

* CHECK dout1_45 Vdout1_45ck107 = 0.9 time = 540
.meas tran vdout1_45ck107 FIND v(dout1_45) AT=540.025n

* CHECK dout1_46 Vdout1_46ck107 = 0.9 time = 540
.meas tran vdout1_46ck107 FIND v(dout1_46) AT=540.025n

* CHECK dout1_47 Vdout1_47ck107 = 0.9 time = 540
.meas tran vdout1_47ck107 FIND v(dout1_47) AT=540.025n

* CHECK dout1_48 Vdout1_48ck107 = 0.9 time = 540
.meas tran vdout1_48ck107 FIND v(dout1_48) AT=540.025n

* CHECK dout1_49 Vdout1_49ck107 = 0 time = 540
.meas tran vdout1_49ck107 FIND v(dout1_49) AT=540.025n

* CHECK dout1_50 Vdout1_50ck107 = 0.9 time = 540
.meas tran vdout1_50ck107 FIND v(dout1_50) AT=540.025n

* CHECK dout1_51 Vdout1_51ck107 = 0 time = 540
.meas tran vdout1_51ck107 FIND v(dout1_51) AT=540.025n

* CHECK dout1_52 Vdout1_52ck107 = 0.9 time = 540
.meas tran vdout1_52ck107 FIND v(dout1_52) AT=540.025n

* CHECK dout1_53 Vdout1_53ck107 = 0 time = 540
.meas tran vdout1_53ck107 FIND v(dout1_53) AT=540.025n

* CHECK dout1_54 Vdout1_54ck107 = 0.9 time = 540
.meas tran vdout1_54ck107 FIND v(dout1_54) AT=540.025n

* CHECK dout1_55 Vdout1_55ck107 = 0.9 time = 540
.meas tran vdout1_55ck107 FIND v(dout1_55) AT=540.025n

* CHECK dout1_56 Vdout1_56ck107 = 0.9 time = 540
.meas tran vdout1_56ck107 FIND v(dout1_56) AT=540.025n

* CHECK dout1_57 Vdout1_57ck107 = 0 time = 540
.meas tran vdout1_57ck107 FIND v(dout1_57) AT=540.025n

* CHECK dout1_58 Vdout1_58ck107 = 0.9 time = 540
.meas tran vdout1_58ck107 FIND v(dout1_58) AT=540.025n

* CHECK dout1_59 Vdout1_59ck107 = 0 time = 540
.meas tran vdout1_59ck107 FIND v(dout1_59) AT=540.025n

* CHECK dout1_60 Vdout1_60ck107 = 0 time = 540
.meas tran vdout1_60ck107 FIND v(dout1_60) AT=540.025n

* CHECK dout1_61 Vdout1_61ck107 = 0.9 time = 540
.meas tran vdout1_61ck107 FIND v(dout1_61) AT=540.025n

* CHECK dout1_62 Vdout1_62ck107 = 0.9 time = 540
.meas tran vdout1_62ck107 FIND v(dout1_62) AT=540.025n

* CHECK dout1_63 Vdout1_63ck107 = 0 time = 540
.meas tran vdout1_63ck107 FIND v(dout1_63) AT=540.025n

* CHECK dout1_64 Vdout1_64ck107 = 0.9 time = 540
.meas tran vdout1_64ck107 FIND v(dout1_64) AT=540.025n

* CHECK dout1_65 Vdout1_65ck107 = 0 time = 540
.meas tran vdout1_65ck107 FIND v(dout1_65) AT=540.025n

* CHECK dout1_66 Vdout1_66ck107 = 0 time = 540
.meas tran vdout1_66ck107 FIND v(dout1_66) AT=540.025n

* CHECK dout1_67 Vdout1_67ck107 = 0 time = 540
.meas tran vdout1_67ck107 FIND v(dout1_67) AT=540.025n

* CHECK dout1_68 Vdout1_68ck107 = 0.9 time = 540
.meas tran vdout1_68ck107 FIND v(dout1_68) AT=540.025n

* CHECK dout1_69 Vdout1_69ck107 = 0 time = 540
.meas tran vdout1_69ck107 FIND v(dout1_69) AT=540.025n

* CHECK dout1_70 Vdout1_70ck107 = 0.9 time = 540
.meas tran vdout1_70ck107 FIND v(dout1_70) AT=540.025n

* CHECK dout1_71 Vdout1_71ck107 = 0.9 time = 540
.meas tran vdout1_71ck107 FIND v(dout1_71) AT=540.025n

* CHECK dout1_72 Vdout1_72ck107 = 0 time = 540
.meas tran vdout1_72ck107 FIND v(dout1_72) AT=540.025n

* CHECK dout1_73 Vdout1_73ck107 = 0.9 time = 540
.meas tran vdout1_73ck107 FIND v(dout1_73) AT=540.025n

* CHECK dout1_74 Vdout1_74ck107 = 0 time = 540
.meas tran vdout1_74ck107 FIND v(dout1_74) AT=540.025n

* CHECK dout1_75 Vdout1_75ck107 = 0.9 time = 540
.meas tran vdout1_75ck107 FIND v(dout1_75) AT=540.025n

* CHECK dout1_76 Vdout1_76ck107 = 0 time = 540
.meas tran vdout1_76ck107 FIND v(dout1_76) AT=540.025n

* CHECK dout1_77 Vdout1_77ck107 = 0 time = 540
.meas tran vdout1_77ck107 FIND v(dout1_77) AT=540.025n

* CHECK dout1_78 Vdout1_78ck107 = 0 time = 540
.meas tran vdout1_78ck107 FIND v(dout1_78) AT=540.025n

* CHECK dout1_79 Vdout1_79ck107 = 0.9 time = 540
.meas tran vdout1_79ck107 FIND v(dout1_79) AT=540.025n

* CHECK dout1_80 Vdout1_80ck107 = 0 time = 540
.meas tran vdout1_80ck107 FIND v(dout1_80) AT=540.025n

* CHECK dout1_81 Vdout1_81ck107 = 0.9 time = 540
.meas tran vdout1_81ck107 FIND v(dout1_81) AT=540.025n

* CHECK dout1_82 Vdout1_82ck107 = 0.9 time = 540
.meas tran vdout1_82ck107 FIND v(dout1_82) AT=540.025n

* CHECK dout1_83 Vdout1_83ck107 = 0.9 time = 540
.meas tran vdout1_83ck107 FIND v(dout1_83) AT=540.025n

* CHECK dout1_84 Vdout1_84ck107 = 0 time = 540
.meas tran vdout1_84ck107 FIND v(dout1_84) AT=540.025n

* CHECK dout1_85 Vdout1_85ck107 = 0 time = 540
.meas tran vdout1_85ck107 FIND v(dout1_85) AT=540.025n

* CHECK dout1_86 Vdout1_86ck107 = 0 time = 540
.meas tran vdout1_86ck107 FIND v(dout1_86) AT=540.025n

* CHECK dout1_87 Vdout1_87ck107 = 0 time = 540
.meas tran vdout1_87ck107 FIND v(dout1_87) AT=540.025n

* CHECK dout1_88 Vdout1_88ck107 = 0 time = 540
.meas tran vdout1_88ck107 FIND v(dout1_88) AT=540.025n

* CHECK dout1_89 Vdout1_89ck107 = 0 time = 540
.meas tran vdout1_89ck107 FIND v(dout1_89) AT=540.025n

* CHECK dout1_90 Vdout1_90ck107 = 0.9 time = 540
.meas tran vdout1_90ck107 FIND v(dout1_90) AT=540.025n

* CHECK dout1_91 Vdout1_91ck107 = 0 time = 540
.meas tran vdout1_91ck107 FIND v(dout1_91) AT=540.025n

* CHECK dout1_92 Vdout1_92ck107 = 0 time = 540
.meas tran vdout1_92ck107 FIND v(dout1_92) AT=540.025n

* CHECK dout1_93 Vdout1_93ck107 = 0.9 time = 540
.meas tran vdout1_93ck107 FIND v(dout1_93) AT=540.025n

* CHECK dout1_94 Vdout1_94ck107 = 0 time = 540
.meas tran vdout1_94ck107 FIND v(dout1_94) AT=540.025n

* CHECK dout1_95 Vdout1_95ck107 = 0 time = 540
.meas tran vdout1_95ck107 FIND v(dout1_95) AT=540.025n

* CHECK dout1_96 Vdout1_96ck107 = 0.9 time = 540
.meas tran vdout1_96ck107 FIND v(dout1_96) AT=540.025n

* CHECK dout1_97 Vdout1_97ck107 = 0.9 time = 540
.meas tran vdout1_97ck107 FIND v(dout1_97) AT=540.025n

* CHECK dout1_98 Vdout1_98ck107 = 0 time = 540
.meas tran vdout1_98ck107 FIND v(dout1_98) AT=540.025n

* CHECK dout1_99 Vdout1_99ck107 = 0.9 time = 540
.meas tran vdout1_99ck107 FIND v(dout1_99) AT=540.025n

* CHECK dout1_100 Vdout1_100ck107 = 0.9 time = 540
.meas tran vdout1_100ck107 FIND v(dout1_100) AT=540.025n

* CHECK dout1_101 Vdout1_101ck107 = 0 time = 540
.meas tran vdout1_101ck107 FIND v(dout1_101) AT=540.025n

* CHECK dout1_102 Vdout1_102ck107 = 0 time = 540
.meas tran vdout1_102ck107 FIND v(dout1_102) AT=540.025n

* CHECK dout1_103 Vdout1_103ck107 = 0 time = 540
.meas tran vdout1_103ck107 FIND v(dout1_103) AT=540.025n

* CHECK dout1_104 Vdout1_104ck107 = 0 time = 540
.meas tran vdout1_104ck107 FIND v(dout1_104) AT=540.025n

* CHECK dout1_105 Vdout1_105ck107 = 0 time = 540
.meas tran vdout1_105ck107 FIND v(dout1_105) AT=540.025n

* CHECK dout1_106 Vdout1_106ck107 = 0.9 time = 540
.meas tran vdout1_106ck107 FIND v(dout1_106) AT=540.025n

* CHECK dout1_107 Vdout1_107ck107 = 0 time = 540
.meas tran vdout1_107ck107 FIND v(dout1_107) AT=540.025n

* CHECK dout1_108 Vdout1_108ck107 = 0 time = 540
.meas tran vdout1_108ck107 FIND v(dout1_108) AT=540.025n

* CHECK dout1_109 Vdout1_109ck107 = 0.9 time = 540
.meas tran vdout1_109ck107 FIND v(dout1_109) AT=540.025n

* CHECK dout1_110 Vdout1_110ck107 = 0 time = 540
.meas tran vdout1_110ck107 FIND v(dout1_110) AT=540.025n

* CHECK dout1_111 Vdout1_111ck107 = 0.9 time = 540
.meas tran vdout1_111ck107 FIND v(dout1_111) AT=540.025n

* CHECK dout1_112 Vdout1_112ck107 = 0.9 time = 540
.meas tran vdout1_112ck107 FIND v(dout1_112) AT=540.025n

* CHECK dout1_113 Vdout1_113ck107 = 0 time = 540
.meas tran vdout1_113ck107 FIND v(dout1_113) AT=540.025n

* CHECK dout1_114 Vdout1_114ck107 = 0.9 time = 540
.meas tran vdout1_114ck107 FIND v(dout1_114) AT=540.025n

* CHECK dout1_115 Vdout1_115ck107 = 0 time = 540
.meas tran vdout1_115ck107 FIND v(dout1_115) AT=540.025n

* CHECK dout1_116 Vdout1_116ck107 = 0 time = 540
.meas tran vdout1_116ck107 FIND v(dout1_116) AT=540.025n

* CHECK dout1_117 Vdout1_117ck107 = 0.9 time = 540
.meas tran vdout1_117ck107 FIND v(dout1_117) AT=540.025n

* CHECK dout1_118 Vdout1_118ck107 = 0 time = 540
.meas tran vdout1_118ck107 FIND v(dout1_118) AT=540.025n

* CHECK dout1_119 Vdout1_119ck107 = 0.9 time = 540
.meas tran vdout1_119ck107 FIND v(dout1_119) AT=540.025n

* CHECK dout1_0 Vdout1_0ck108 = 0 time = 545
.meas tran vdout1_0ck108 FIND v(dout1_0) AT=545.025n

* CHECK dout1_1 Vdout1_1ck108 = 0 time = 545
.meas tran vdout1_1ck108 FIND v(dout1_1) AT=545.025n

* CHECK dout1_2 Vdout1_2ck108 = 0 time = 545
.meas tran vdout1_2ck108 FIND v(dout1_2) AT=545.025n

* CHECK dout1_3 Vdout1_3ck108 = 0.9 time = 545
.meas tran vdout1_3ck108 FIND v(dout1_3) AT=545.025n

* CHECK dout1_4 Vdout1_4ck108 = 0.9 time = 545
.meas tran vdout1_4ck108 FIND v(dout1_4) AT=545.025n

* CHECK dout1_5 Vdout1_5ck108 = 0 time = 545
.meas tran vdout1_5ck108 FIND v(dout1_5) AT=545.025n

* CHECK dout1_6 Vdout1_6ck108 = 0 time = 545
.meas tran vdout1_6ck108 FIND v(dout1_6) AT=545.025n

* CHECK dout1_7 Vdout1_7ck108 = 0 time = 545
.meas tran vdout1_7ck108 FIND v(dout1_7) AT=545.025n

* CHECK dout1_8 Vdout1_8ck108 = 0 time = 545
.meas tran vdout1_8ck108 FIND v(dout1_8) AT=545.025n

* CHECK dout1_9 Vdout1_9ck108 = 0.9 time = 545
.meas tran vdout1_9ck108 FIND v(dout1_9) AT=545.025n

* CHECK dout1_10 Vdout1_10ck108 = 0 time = 545
.meas tran vdout1_10ck108 FIND v(dout1_10) AT=545.025n

* CHECK dout1_11 Vdout1_11ck108 = 0.9 time = 545
.meas tran vdout1_11ck108 FIND v(dout1_11) AT=545.025n

* CHECK dout1_12 Vdout1_12ck108 = 0 time = 545
.meas tran vdout1_12ck108 FIND v(dout1_12) AT=545.025n

* CHECK dout1_13 Vdout1_13ck108 = 0 time = 545
.meas tran vdout1_13ck108 FIND v(dout1_13) AT=545.025n

* CHECK dout1_14 Vdout1_14ck108 = 0.9 time = 545
.meas tran vdout1_14ck108 FIND v(dout1_14) AT=545.025n

* CHECK dout1_15 Vdout1_15ck108 = 0 time = 545
.meas tran vdout1_15ck108 FIND v(dout1_15) AT=545.025n

* CHECK dout1_16 Vdout1_16ck108 = 0 time = 545
.meas tran vdout1_16ck108 FIND v(dout1_16) AT=545.025n

* CHECK dout1_17 Vdout1_17ck108 = 0.9 time = 545
.meas tran vdout1_17ck108 FIND v(dout1_17) AT=545.025n

* CHECK dout1_18 Vdout1_18ck108 = 0 time = 545
.meas tran vdout1_18ck108 FIND v(dout1_18) AT=545.025n

* CHECK dout1_19 Vdout1_19ck108 = 0 time = 545
.meas tran vdout1_19ck108 FIND v(dout1_19) AT=545.025n

* CHECK dout1_20 Vdout1_20ck108 = 0 time = 545
.meas tran vdout1_20ck108 FIND v(dout1_20) AT=545.025n

* CHECK dout1_21 Vdout1_21ck108 = 0 time = 545
.meas tran vdout1_21ck108 FIND v(dout1_21) AT=545.025n

* CHECK dout1_22 Vdout1_22ck108 = 0 time = 545
.meas tran vdout1_22ck108 FIND v(dout1_22) AT=545.025n

* CHECK dout1_23 Vdout1_23ck108 = 0.9 time = 545
.meas tran vdout1_23ck108 FIND v(dout1_23) AT=545.025n

* CHECK dout1_24 Vdout1_24ck108 = 0 time = 545
.meas tran vdout1_24ck108 FIND v(dout1_24) AT=545.025n

* CHECK dout1_25 Vdout1_25ck108 = 0.9 time = 545
.meas tran vdout1_25ck108 FIND v(dout1_25) AT=545.025n

* CHECK dout1_26 Vdout1_26ck108 = 0 time = 545
.meas tran vdout1_26ck108 FIND v(dout1_26) AT=545.025n

* CHECK dout1_27 Vdout1_27ck108 = 0 time = 545
.meas tran vdout1_27ck108 FIND v(dout1_27) AT=545.025n

* CHECK dout1_28 Vdout1_28ck108 = 0.9 time = 545
.meas tran vdout1_28ck108 FIND v(dout1_28) AT=545.025n

* CHECK dout1_29 Vdout1_29ck108 = 0.9 time = 545
.meas tran vdout1_29ck108 FIND v(dout1_29) AT=545.025n

* CHECK dout1_30 Vdout1_30ck108 = 0 time = 545
.meas tran vdout1_30ck108 FIND v(dout1_30) AT=545.025n

* CHECK dout1_31 Vdout1_31ck108 = 0.9 time = 545
.meas tran vdout1_31ck108 FIND v(dout1_31) AT=545.025n

* CHECK dout1_32 Vdout1_32ck108 = 0 time = 545
.meas tran vdout1_32ck108 FIND v(dout1_32) AT=545.025n

* CHECK dout1_33 Vdout1_33ck108 = 0 time = 545
.meas tran vdout1_33ck108 FIND v(dout1_33) AT=545.025n

* CHECK dout1_34 Vdout1_34ck108 = 0.9 time = 545
.meas tran vdout1_34ck108 FIND v(dout1_34) AT=545.025n

* CHECK dout1_35 Vdout1_35ck108 = 0 time = 545
.meas tran vdout1_35ck108 FIND v(dout1_35) AT=545.025n

* CHECK dout1_36 Vdout1_36ck108 = 0.9 time = 545
.meas tran vdout1_36ck108 FIND v(dout1_36) AT=545.025n

* CHECK dout1_37 Vdout1_37ck108 = 0.9 time = 545
.meas tran vdout1_37ck108 FIND v(dout1_37) AT=545.025n

* CHECK dout1_38 Vdout1_38ck108 = 0.9 time = 545
.meas tran vdout1_38ck108 FIND v(dout1_38) AT=545.025n

* CHECK dout1_39 Vdout1_39ck108 = 0.9 time = 545
.meas tran vdout1_39ck108 FIND v(dout1_39) AT=545.025n

* CHECK dout1_40 Vdout1_40ck108 = 0.9 time = 545
.meas tran vdout1_40ck108 FIND v(dout1_40) AT=545.025n

* CHECK dout1_41 Vdout1_41ck108 = 0 time = 545
.meas tran vdout1_41ck108 FIND v(dout1_41) AT=545.025n

* CHECK dout1_42 Vdout1_42ck108 = 0.9 time = 545
.meas tran vdout1_42ck108 FIND v(dout1_42) AT=545.025n

* CHECK dout1_43 Vdout1_43ck108 = 0.9 time = 545
.meas tran vdout1_43ck108 FIND v(dout1_43) AT=545.025n

* CHECK dout1_44 Vdout1_44ck108 = 0 time = 545
.meas tran vdout1_44ck108 FIND v(dout1_44) AT=545.025n

* CHECK dout1_45 Vdout1_45ck108 = 0 time = 545
.meas tran vdout1_45ck108 FIND v(dout1_45) AT=545.025n

* CHECK dout1_46 Vdout1_46ck108 = 0 time = 545
.meas tran vdout1_46ck108 FIND v(dout1_46) AT=545.025n

* CHECK dout1_47 Vdout1_47ck108 = 0 time = 545
.meas tran vdout1_47ck108 FIND v(dout1_47) AT=545.025n

* CHECK dout1_48 Vdout1_48ck108 = 0.9 time = 545
.meas tran vdout1_48ck108 FIND v(dout1_48) AT=545.025n

* CHECK dout1_49 Vdout1_49ck108 = 0 time = 545
.meas tran vdout1_49ck108 FIND v(dout1_49) AT=545.025n

* CHECK dout1_50 Vdout1_50ck108 = 0.9 time = 545
.meas tran vdout1_50ck108 FIND v(dout1_50) AT=545.025n

* CHECK dout1_51 Vdout1_51ck108 = 0.9 time = 545
.meas tran vdout1_51ck108 FIND v(dout1_51) AT=545.025n

* CHECK dout1_52 Vdout1_52ck108 = 0 time = 545
.meas tran vdout1_52ck108 FIND v(dout1_52) AT=545.025n

* CHECK dout1_53 Vdout1_53ck108 = 0 time = 545
.meas tran vdout1_53ck108 FIND v(dout1_53) AT=545.025n

* CHECK dout1_54 Vdout1_54ck108 = 0 time = 545
.meas tran vdout1_54ck108 FIND v(dout1_54) AT=545.025n

* CHECK dout1_55 Vdout1_55ck108 = 0 time = 545
.meas tran vdout1_55ck108 FIND v(dout1_55) AT=545.025n

* CHECK dout1_56 Vdout1_56ck108 = 0 time = 545
.meas tran vdout1_56ck108 FIND v(dout1_56) AT=545.025n

* CHECK dout1_57 Vdout1_57ck108 = 0 time = 545
.meas tran vdout1_57ck108 FIND v(dout1_57) AT=545.025n

* CHECK dout1_58 Vdout1_58ck108 = 0.9 time = 545
.meas tran vdout1_58ck108 FIND v(dout1_58) AT=545.025n

* CHECK dout1_59 Vdout1_59ck108 = 0.9 time = 545
.meas tran vdout1_59ck108 FIND v(dout1_59) AT=545.025n

* CHECK dout1_60 Vdout1_60ck108 = 0 time = 545
.meas tran vdout1_60ck108 FIND v(dout1_60) AT=545.025n

* CHECK dout1_61 Vdout1_61ck108 = 0.9 time = 545
.meas tran vdout1_61ck108 FIND v(dout1_61) AT=545.025n

* CHECK dout1_62 Vdout1_62ck108 = 0 time = 545
.meas tran vdout1_62ck108 FIND v(dout1_62) AT=545.025n

* CHECK dout1_63 Vdout1_63ck108 = 0.9 time = 545
.meas tran vdout1_63ck108 FIND v(dout1_63) AT=545.025n

* CHECK dout1_64 Vdout1_64ck108 = 0.9 time = 545
.meas tran vdout1_64ck108 FIND v(dout1_64) AT=545.025n

* CHECK dout1_65 Vdout1_65ck108 = 0.9 time = 545
.meas tran vdout1_65ck108 FIND v(dout1_65) AT=545.025n

* CHECK dout1_66 Vdout1_66ck108 = 0.9 time = 545
.meas tran vdout1_66ck108 FIND v(dout1_66) AT=545.025n

* CHECK dout1_67 Vdout1_67ck108 = 0.9 time = 545
.meas tran vdout1_67ck108 FIND v(dout1_67) AT=545.025n

* CHECK dout1_68 Vdout1_68ck108 = 0.9 time = 545
.meas tran vdout1_68ck108 FIND v(dout1_68) AT=545.025n

* CHECK dout1_69 Vdout1_69ck108 = 0 time = 545
.meas tran vdout1_69ck108 FIND v(dout1_69) AT=545.025n

* CHECK dout1_70 Vdout1_70ck108 = 0.9 time = 545
.meas tran vdout1_70ck108 FIND v(dout1_70) AT=545.025n

* CHECK dout1_71 Vdout1_71ck108 = 0.9 time = 545
.meas tran vdout1_71ck108 FIND v(dout1_71) AT=545.025n

* CHECK dout1_72 Vdout1_72ck108 = 0.9 time = 545
.meas tran vdout1_72ck108 FIND v(dout1_72) AT=545.025n

* CHECK dout1_73 Vdout1_73ck108 = 0 time = 545
.meas tran vdout1_73ck108 FIND v(dout1_73) AT=545.025n

* CHECK dout1_74 Vdout1_74ck108 = 0 time = 545
.meas tran vdout1_74ck108 FIND v(dout1_74) AT=545.025n

* CHECK dout1_75 Vdout1_75ck108 = 0.9 time = 545
.meas tran vdout1_75ck108 FIND v(dout1_75) AT=545.025n

* CHECK dout1_76 Vdout1_76ck108 = 0 time = 545
.meas tran vdout1_76ck108 FIND v(dout1_76) AT=545.025n

* CHECK dout1_77 Vdout1_77ck108 = 0.9 time = 545
.meas tran vdout1_77ck108 FIND v(dout1_77) AT=545.025n

* CHECK dout1_78 Vdout1_78ck108 = 0.9 time = 545
.meas tran vdout1_78ck108 FIND v(dout1_78) AT=545.025n

* CHECK dout1_79 Vdout1_79ck108 = 0 time = 545
.meas tran vdout1_79ck108 FIND v(dout1_79) AT=545.025n

* CHECK dout1_80 Vdout1_80ck108 = 0 time = 545
.meas tran vdout1_80ck108 FIND v(dout1_80) AT=545.025n

* CHECK dout1_81 Vdout1_81ck108 = 0 time = 545
.meas tran vdout1_81ck108 FIND v(dout1_81) AT=545.025n

* CHECK dout1_82 Vdout1_82ck108 = 0 time = 545
.meas tran vdout1_82ck108 FIND v(dout1_82) AT=545.025n

* CHECK dout1_83 Vdout1_83ck108 = 0 time = 545
.meas tran vdout1_83ck108 FIND v(dout1_83) AT=545.025n

* CHECK dout1_84 Vdout1_84ck108 = 0 time = 545
.meas tran vdout1_84ck108 FIND v(dout1_84) AT=545.025n

* CHECK dout1_85 Vdout1_85ck108 = 0.9 time = 545
.meas tran vdout1_85ck108 FIND v(dout1_85) AT=545.025n

* CHECK dout1_86 Vdout1_86ck108 = 0.9 time = 545
.meas tran vdout1_86ck108 FIND v(dout1_86) AT=545.025n

* CHECK dout1_87 Vdout1_87ck108 = 0.9 time = 545
.meas tran vdout1_87ck108 FIND v(dout1_87) AT=545.025n

* CHECK dout1_88 Vdout1_88ck108 = 0 time = 545
.meas tran vdout1_88ck108 FIND v(dout1_88) AT=545.025n

* CHECK dout1_89 Vdout1_89ck108 = 0 time = 545
.meas tran vdout1_89ck108 FIND v(dout1_89) AT=545.025n

* CHECK dout1_90 Vdout1_90ck108 = 0.9 time = 545
.meas tran vdout1_90ck108 FIND v(dout1_90) AT=545.025n

* CHECK dout1_91 Vdout1_91ck108 = 0.9 time = 545
.meas tran vdout1_91ck108 FIND v(dout1_91) AT=545.025n

* CHECK dout1_92 Vdout1_92ck108 = 0 time = 545
.meas tran vdout1_92ck108 FIND v(dout1_92) AT=545.025n

* CHECK dout1_93 Vdout1_93ck108 = 0.9 time = 545
.meas tran vdout1_93ck108 FIND v(dout1_93) AT=545.025n

* CHECK dout1_94 Vdout1_94ck108 = 0.9 time = 545
.meas tran vdout1_94ck108 FIND v(dout1_94) AT=545.025n

* CHECK dout1_95 Vdout1_95ck108 = 0.9 time = 545
.meas tran vdout1_95ck108 FIND v(dout1_95) AT=545.025n

* CHECK dout1_96 Vdout1_96ck108 = 0 time = 545
.meas tran vdout1_96ck108 FIND v(dout1_96) AT=545.025n

* CHECK dout1_97 Vdout1_97ck108 = 0 time = 545
.meas tran vdout1_97ck108 FIND v(dout1_97) AT=545.025n

* CHECK dout1_98 Vdout1_98ck108 = 0 time = 545
.meas tran vdout1_98ck108 FIND v(dout1_98) AT=545.025n

* CHECK dout1_99 Vdout1_99ck108 = 0.9 time = 545
.meas tran vdout1_99ck108 FIND v(dout1_99) AT=545.025n

* CHECK dout1_100 Vdout1_100ck108 = 0 time = 545
.meas tran vdout1_100ck108 FIND v(dout1_100) AT=545.025n

* CHECK dout1_101 Vdout1_101ck108 = 0.9 time = 545
.meas tran vdout1_101ck108 FIND v(dout1_101) AT=545.025n

* CHECK dout1_102 Vdout1_102ck108 = 0.9 time = 545
.meas tran vdout1_102ck108 FIND v(dout1_102) AT=545.025n

* CHECK dout1_103 Vdout1_103ck108 = 0 time = 545
.meas tran vdout1_103ck108 FIND v(dout1_103) AT=545.025n

* CHECK dout1_104 Vdout1_104ck108 = 0 time = 545
.meas tran vdout1_104ck108 FIND v(dout1_104) AT=545.025n

* CHECK dout1_105 Vdout1_105ck108 = 0 time = 545
.meas tran vdout1_105ck108 FIND v(dout1_105) AT=545.025n

* CHECK dout1_106 Vdout1_106ck108 = 0 time = 545
.meas tran vdout1_106ck108 FIND v(dout1_106) AT=545.025n

* CHECK dout1_107 Vdout1_107ck108 = 0 time = 545
.meas tran vdout1_107ck108 FIND v(dout1_107) AT=545.025n

* CHECK dout1_108 Vdout1_108ck108 = 0 time = 545
.meas tran vdout1_108ck108 FIND v(dout1_108) AT=545.025n

* CHECK dout1_109 Vdout1_109ck108 = 0.9 time = 545
.meas tran vdout1_109ck108 FIND v(dout1_109) AT=545.025n

* CHECK dout1_110 Vdout1_110ck108 = 0 time = 545
.meas tran vdout1_110ck108 FIND v(dout1_110) AT=545.025n

* CHECK dout1_111 Vdout1_111ck108 = 0.9 time = 545
.meas tran vdout1_111ck108 FIND v(dout1_111) AT=545.025n

* CHECK dout1_112 Vdout1_112ck108 = 0.9 time = 545
.meas tran vdout1_112ck108 FIND v(dout1_112) AT=545.025n

* CHECK dout1_113 Vdout1_113ck108 = 0.9 time = 545
.meas tran vdout1_113ck108 FIND v(dout1_113) AT=545.025n

* CHECK dout1_114 Vdout1_114ck108 = 0 time = 545
.meas tran vdout1_114ck108 FIND v(dout1_114) AT=545.025n

* CHECK dout1_115 Vdout1_115ck108 = 0.9 time = 545
.meas tran vdout1_115ck108 FIND v(dout1_115) AT=545.025n

* CHECK dout1_116 Vdout1_116ck108 = 0 time = 545
.meas tran vdout1_116ck108 FIND v(dout1_116) AT=545.025n

* CHECK dout1_117 Vdout1_117ck108 = 0.9 time = 545
.meas tran vdout1_117ck108 FIND v(dout1_117) AT=545.025n

* CHECK dout1_118 Vdout1_118ck108 = 0 time = 545
.meas tran vdout1_118ck108 FIND v(dout1_118) AT=545.025n

* CHECK dout1_119 Vdout1_119ck108 = 0 time = 545
.meas tran vdout1_119ck108 FIND v(dout1_119) AT=545.025n

* CHECK dout1_0 Vdout1_0ck109 = 0 time = 550
.meas tran vdout1_0ck109 FIND v(dout1_0) AT=550.025n

* CHECK dout1_1 Vdout1_1ck109 = 0.9 time = 550
.meas tran vdout1_1ck109 FIND v(dout1_1) AT=550.025n

* CHECK dout1_2 Vdout1_2ck109 = 0 time = 550
.meas tran vdout1_2ck109 FIND v(dout1_2) AT=550.025n

* CHECK dout1_3 Vdout1_3ck109 = 0 time = 550
.meas tran vdout1_3ck109 FIND v(dout1_3) AT=550.025n

* CHECK dout1_4 Vdout1_4ck109 = 0 time = 550
.meas tran vdout1_4ck109 FIND v(dout1_4) AT=550.025n

* CHECK dout1_5 Vdout1_5ck109 = 0 time = 550
.meas tran vdout1_5ck109 FIND v(dout1_5) AT=550.025n

* CHECK dout1_6 Vdout1_6ck109 = 0.9 time = 550
.meas tran vdout1_6ck109 FIND v(dout1_6) AT=550.025n

* CHECK dout1_7 Vdout1_7ck109 = 0 time = 550
.meas tran vdout1_7ck109 FIND v(dout1_7) AT=550.025n

* CHECK dout1_8 Vdout1_8ck109 = 0 time = 550
.meas tran vdout1_8ck109 FIND v(dout1_8) AT=550.025n

* CHECK dout1_9 Vdout1_9ck109 = 0 time = 550
.meas tran vdout1_9ck109 FIND v(dout1_9) AT=550.025n

* CHECK dout1_10 Vdout1_10ck109 = 0 time = 550
.meas tran vdout1_10ck109 FIND v(dout1_10) AT=550.025n

* CHECK dout1_11 Vdout1_11ck109 = 0.9 time = 550
.meas tran vdout1_11ck109 FIND v(dout1_11) AT=550.025n

* CHECK dout1_12 Vdout1_12ck109 = 0.9 time = 550
.meas tran vdout1_12ck109 FIND v(dout1_12) AT=550.025n

* CHECK dout1_13 Vdout1_13ck109 = 0.9 time = 550
.meas tran vdout1_13ck109 FIND v(dout1_13) AT=550.025n

* CHECK dout1_14 Vdout1_14ck109 = 0 time = 550
.meas tran vdout1_14ck109 FIND v(dout1_14) AT=550.025n

* CHECK dout1_15 Vdout1_15ck109 = 0.9 time = 550
.meas tran vdout1_15ck109 FIND v(dout1_15) AT=550.025n

* CHECK dout1_16 Vdout1_16ck109 = 0 time = 550
.meas tran vdout1_16ck109 FIND v(dout1_16) AT=550.025n

* CHECK dout1_17 Vdout1_17ck109 = 0 time = 550
.meas tran vdout1_17ck109 FIND v(dout1_17) AT=550.025n

* CHECK dout1_18 Vdout1_18ck109 = 0.9 time = 550
.meas tran vdout1_18ck109 FIND v(dout1_18) AT=550.025n

* CHECK dout1_19 Vdout1_19ck109 = 0.9 time = 550
.meas tran vdout1_19ck109 FIND v(dout1_19) AT=550.025n

* CHECK dout1_20 Vdout1_20ck109 = 0.9 time = 550
.meas tran vdout1_20ck109 FIND v(dout1_20) AT=550.025n

* CHECK dout1_21 Vdout1_21ck109 = 0.9 time = 550
.meas tran vdout1_21ck109 FIND v(dout1_21) AT=550.025n

* CHECK dout1_22 Vdout1_22ck109 = 0.9 time = 550
.meas tran vdout1_22ck109 FIND v(dout1_22) AT=550.025n

* CHECK dout1_23 Vdout1_23ck109 = 0 time = 550
.meas tran vdout1_23ck109 FIND v(dout1_23) AT=550.025n

* CHECK dout1_24 Vdout1_24ck109 = 0 time = 550
.meas tran vdout1_24ck109 FIND v(dout1_24) AT=550.025n

* CHECK dout1_25 Vdout1_25ck109 = 0.9 time = 550
.meas tran vdout1_25ck109 FIND v(dout1_25) AT=550.025n

* CHECK dout1_26 Vdout1_26ck109 = 0.9 time = 550
.meas tran vdout1_26ck109 FIND v(dout1_26) AT=550.025n

* CHECK dout1_27 Vdout1_27ck109 = 0 time = 550
.meas tran vdout1_27ck109 FIND v(dout1_27) AT=550.025n

* CHECK dout1_28 Vdout1_28ck109 = 0 time = 550
.meas tran vdout1_28ck109 FIND v(dout1_28) AT=550.025n

* CHECK dout1_29 Vdout1_29ck109 = 0 time = 550
.meas tran vdout1_29ck109 FIND v(dout1_29) AT=550.025n

* CHECK dout1_30 Vdout1_30ck109 = 0 time = 550
.meas tran vdout1_30ck109 FIND v(dout1_30) AT=550.025n

* CHECK dout1_31 Vdout1_31ck109 = 0.9 time = 550
.meas tran vdout1_31ck109 FIND v(dout1_31) AT=550.025n

* CHECK dout1_32 Vdout1_32ck109 = 0 time = 550
.meas tran vdout1_32ck109 FIND v(dout1_32) AT=550.025n

* CHECK dout1_33 Vdout1_33ck109 = 0.9 time = 550
.meas tran vdout1_33ck109 FIND v(dout1_33) AT=550.025n

* CHECK dout1_34 Vdout1_34ck109 = 0.9 time = 550
.meas tran vdout1_34ck109 FIND v(dout1_34) AT=550.025n

* CHECK dout1_35 Vdout1_35ck109 = 0 time = 550
.meas tran vdout1_35ck109 FIND v(dout1_35) AT=550.025n

* CHECK dout1_36 Vdout1_36ck109 = 0.9 time = 550
.meas tran vdout1_36ck109 FIND v(dout1_36) AT=550.025n

* CHECK dout1_37 Vdout1_37ck109 = 0.9 time = 550
.meas tran vdout1_37ck109 FIND v(dout1_37) AT=550.025n

* CHECK dout1_38 Vdout1_38ck109 = 0.9 time = 550
.meas tran vdout1_38ck109 FIND v(dout1_38) AT=550.025n

* CHECK dout1_39 Vdout1_39ck109 = 0 time = 550
.meas tran vdout1_39ck109 FIND v(dout1_39) AT=550.025n

* CHECK dout1_40 Vdout1_40ck109 = 0.9 time = 550
.meas tran vdout1_40ck109 FIND v(dout1_40) AT=550.025n

* CHECK dout1_41 Vdout1_41ck109 = 0.9 time = 550
.meas tran vdout1_41ck109 FIND v(dout1_41) AT=550.025n

* CHECK dout1_42 Vdout1_42ck109 = 0.9 time = 550
.meas tran vdout1_42ck109 FIND v(dout1_42) AT=550.025n

* CHECK dout1_43 Vdout1_43ck109 = 0.9 time = 550
.meas tran vdout1_43ck109 FIND v(dout1_43) AT=550.025n

* CHECK dout1_44 Vdout1_44ck109 = 0.9 time = 550
.meas tran vdout1_44ck109 FIND v(dout1_44) AT=550.025n

* CHECK dout1_45 Vdout1_45ck109 = 0.9 time = 550
.meas tran vdout1_45ck109 FIND v(dout1_45) AT=550.025n

* CHECK dout1_46 Vdout1_46ck109 = 0.9 time = 550
.meas tran vdout1_46ck109 FIND v(dout1_46) AT=550.025n

* CHECK dout1_47 Vdout1_47ck109 = 0.9 time = 550
.meas tran vdout1_47ck109 FIND v(dout1_47) AT=550.025n

* CHECK dout1_48 Vdout1_48ck109 = 0.9 time = 550
.meas tran vdout1_48ck109 FIND v(dout1_48) AT=550.025n

* CHECK dout1_49 Vdout1_49ck109 = 0 time = 550
.meas tran vdout1_49ck109 FIND v(dout1_49) AT=550.025n

* CHECK dout1_50 Vdout1_50ck109 = 0.9 time = 550
.meas tran vdout1_50ck109 FIND v(dout1_50) AT=550.025n

* CHECK dout1_51 Vdout1_51ck109 = 0 time = 550
.meas tran vdout1_51ck109 FIND v(dout1_51) AT=550.025n

* CHECK dout1_52 Vdout1_52ck109 = 0.9 time = 550
.meas tran vdout1_52ck109 FIND v(dout1_52) AT=550.025n

* CHECK dout1_53 Vdout1_53ck109 = 0 time = 550
.meas tran vdout1_53ck109 FIND v(dout1_53) AT=550.025n

* CHECK dout1_54 Vdout1_54ck109 = 0.9 time = 550
.meas tran vdout1_54ck109 FIND v(dout1_54) AT=550.025n

* CHECK dout1_55 Vdout1_55ck109 = 0.9 time = 550
.meas tran vdout1_55ck109 FIND v(dout1_55) AT=550.025n

* CHECK dout1_56 Vdout1_56ck109 = 0.9 time = 550
.meas tran vdout1_56ck109 FIND v(dout1_56) AT=550.025n

* CHECK dout1_57 Vdout1_57ck109 = 0 time = 550
.meas tran vdout1_57ck109 FIND v(dout1_57) AT=550.025n

* CHECK dout1_58 Vdout1_58ck109 = 0.9 time = 550
.meas tran vdout1_58ck109 FIND v(dout1_58) AT=550.025n

* CHECK dout1_59 Vdout1_59ck109 = 0 time = 550
.meas tran vdout1_59ck109 FIND v(dout1_59) AT=550.025n

* CHECK dout1_60 Vdout1_60ck109 = 0 time = 550
.meas tran vdout1_60ck109 FIND v(dout1_60) AT=550.025n

* CHECK dout1_61 Vdout1_61ck109 = 0.9 time = 550
.meas tran vdout1_61ck109 FIND v(dout1_61) AT=550.025n

* CHECK dout1_62 Vdout1_62ck109 = 0.9 time = 550
.meas tran vdout1_62ck109 FIND v(dout1_62) AT=550.025n

* CHECK dout1_63 Vdout1_63ck109 = 0 time = 550
.meas tran vdout1_63ck109 FIND v(dout1_63) AT=550.025n

* CHECK dout1_64 Vdout1_64ck109 = 0.9 time = 550
.meas tran vdout1_64ck109 FIND v(dout1_64) AT=550.025n

* CHECK dout1_65 Vdout1_65ck109 = 0 time = 550
.meas tran vdout1_65ck109 FIND v(dout1_65) AT=550.025n

* CHECK dout1_66 Vdout1_66ck109 = 0 time = 550
.meas tran vdout1_66ck109 FIND v(dout1_66) AT=550.025n

* CHECK dout1_67 Vdout1_67ck109 = 0 time = 550
.meas tran vdout1_67ck109 FIND v(dout1_67) AT=550.025n

* CHECK dout1_68 Vdout1_68ck109 = 0.9 time = 550
.meas tran vdout1_68ck109 FIND v(dout1_68) AT=550.025n

* CHECK dout1_69 Vdout1_69ck109 = 0 time = 550
.meas tran vdout1_69ck109 FIND v(dout1_69) AT=550.025n

* CHECK dout1_70 Vdout1_70ck109 = 0.9 time = 550
.meas tran vdout1_70ck109 FIND v(dout1_70) AT=550.025n

* CHECK dout1_71 Vdout1_71ck109 = 0.9 time = 550
.meas tran vdout1_71ck109 FIND v(dout1_71) AT=550.025n

* CHECK dout1_72 Vdout1_72ck109 = 0 time = 550
.meas tran vdout1_72ck109 FIND v(dout1_72) AT=550.025n

* CHECK dout1_73 Vdout1_73ck109 = 0.9 time = 550
.meas tran vdout1_73ck109 FIND v(dout1_73) AT=550.025n

* CHECK dout1_74 Vdout1_74ck109 = 0 time = 550
.meas tran vdout1_74ck109 FIND v(dout1_74) AT=550.025n

* CHECK dout1_75 Vdout1_75ck109 = 0.9 time = 550
.meas tran vdout1_75ck109 FIND v(dout1_75) AT=550.025n

* CHECK dout1_76 Vdout1_76ck109 = 0 time = 550
.meas tran vdout1_76ck109 FIND v(dout1_76) AT=550.025n

* CHECK dout1_77 Vdout1_77ck109 = 0 time = 550
.meas tran vdout1_77ck109 FIND v(dout1_77) AT=550.025n

* CHECK dout1_78 Vdout1_78ck109 = 0 time = 550
.meas tran vdout1_78ck109 FIND v(dout1_78) AT=550.025n

* CHECK dout1_79 Vdout1_79ck109 = 0.9 time = 550
.meas tran vdout1_79ck109 FIND v(dout1_79) AT=550.025n

* CHECK dout1_80 Vdout1_80ck109 = 0 time = 550
.meas tran vdout1_80ck109 FIND v(dout1_80) AT=550.025n

* CHECK dout1_81 Vdout1_81ck109 = 0.9 time = 550
.meas tran vdout1_81ck109 FIND v(dout1_81) AT=550.025n

* CHECK dout1_82 Vdout1_82ck109 = 0.9 time = 550
.meas tran vdout1_82ck109 FIND v(dout1_82) AT=550.025n

* CHECK dout1_83 Vdout1_83ck109 = 0.9 time = 550
.meas tran vdout1_83ck109 FIND v(dout1_83) AT=550.025n

* CHECK dout1_84 Vdout1_84ck109 = 0 time = 550
.meas tran vdout1_84ck109 FIND v(dout1_84) AT=550.025n

* CHECK dout1_85 Vdout1_85ck109 = 0 time = 550
.meas tran vdout1_85ck109 FIND v(dout1_85) AT=550.025n

* CHECK dout1_86 Vdout1_86ck109 = 0 time = 550
.meas tran vdout1_86ck109 FIND v(dout1_86) AT=550.025n

* CHECK dout1_87 Vdout1_87ck109 = 0 time = 550
.meas tran vdout1_87ck109 FIND v(dout1_87) AT=550.025n

* CHECK dout1_88 Vdout1_88ck109 = 0 time = 550
.meas tran vdout1_88ck109 FIND v(dout1_88) AT=550.025n

* CHECK dout1_89 Vdout1_89ck109 = 0 time = 550
.meas tran vdout1_89ck109 FIND v(dout1_89) AT=550.025n

* CHECK dout1_90 Vdout1_90ck109 = 0.9 time = 550
.meas tran vdout1_90ck109 FIND v(dout1_90) AT=550.025n

* CHECK dout1_91 Vdout1_91ck109 = 0 time = 550
.meas tran vdout1_91ck109 FIND v(dout1_91) AT=550.025n

* CHECK dout1_92 Vdout1_92ck109 = 0 time = 550
.meas tran vdout1_92ck109 FIND v(dout1_92) AT=550.025n

* CHECK dout1_93 Vdout1_93ck109 = 0.9 time = 550
.meas tran vdout1_93ck109 FIND v(dout1_93) AT=550.025n

* CHECK dout1_94 Vdout1_94ck109 = 0 time = 550
.meas tran vdout1_94ck109 FIND v(dout1_94) AT=550.025n

* CHECK dout1_95 Vdout1_95ck109 = 0 time = 550
.meas tran vdout1_95ck109 FIND v(dout1_95) AT=550.025n

* CHECK dout1_96 Vdout1_96ck109 = 0.9 time = 550
.meas tran vdout1_96ck109 FIND v(dout1_96) AT=550.025n

* CHECK dout1_97 Vdout1_97ck109 = 0.9 time = 550
.meas tran vdout1_97ck109 FIND v(dout1_97) AT=550.025n

* CHECK dout1_98 Vdout1_98ck109 = 0 time = 550
.meas tran vdout1_98ck109 FIND v(dout1_98) AT=550.025n

* CHECK dout1_99 Vdout1_99ck109 = 0.9 time = 550
.meas tran vdout1_99ck109 FIND v(dout1_99) AT=550.025n

* CHECK dout1_100 Vdout1_100ck109 = 0.9 time = 550
.meas tran vdout1_100ck109 FIND v(dout1_100) AT=550.025n

* CHECK dout1_101 Vdout1_101ck109 = 0 time = 550
.meas tran vdout1_101ck109 FIND v(dout1_101) AT=550.025n

* CHECK dout1_102 Vdout1_102ck109 = 0 time = 550
.meas tran vdout1_102ck109 FIND v(dout1_102) AT=550.025n

* CHECK dout1_103 Vdout1_103ck109 = 0 time = 550
.meas tran vdout1_103ck109 FIND v(dout1_103) AT=550.025n

* CHECK dout1_104 Vdout1_104ck109 = 0 time = 550
.meas tran vdout1_104ck109 FIND v(dout1_104) AT=550.025n

* CHECK dout1_105 Vdout1_105ck109 = 0 time = 550
.meas tran vdout1_105ck109 FIND v(dout1_105) AT=550.025n

* CHECK dout1_106 Vdout1_106ck109 = 0.9 time = 550
.meas tran vdout1_106ck109 FIND v(dout1_106) AT=550.025n

* CHECK dout1_107 Vdout1_107ck109 = 0 time = 550
.meas tran vdout1_107ck109 FIND v(dout1_107) AT=550.025n

* CHECK dout1_108 Vdout1_108ck109 = 0 time = 550
.meas tran vdout1_108ck109 FIND v(dout1_108) AT=550.025n

* CHECK dout1_109 Vdout1_109ck109 = 0.9 time = 550
.meas tran vdout1_109ck109 FIND v(dout1_109) AT=550.025n

* CHECK dout1_110 Vdout1_110ck109 = 0 time = 550
.meas tran vdout1_110ck109 FIND v(dout1_110) AT=550.025n

* CHECK dout1_111 Vdout1_111ck109 = 0.9 time = 550
.meas tran vdout1_111ck109 FIND v(dout1_111) AT=550.025n

* CHECK dout1_112 Vdout1_112ck109 = 0.9 time = 550
.meas tran vdout1_112ck109 FIND v(dout1_112) AT=550.025n

* CHECK dout1_113 Vdout1_113ck109 = 0 time = 550
.meas tran vdout1_113ck109 FIND v(dout1_113) AT=550.025n

* CHECK dout1_114 Vdout1_114ck109 = 0.9 time = 550
.meas tran vdout1_114ck109 FIND v(dout1_114) AT=550.025n

* CHECK dout1_115 Vdout1_115ck109 = 0 time = 550
.meas tran vdout1_115ck109 FIND v(dout1_115) AT=550.025n

* CHECK dout1_116 Vdout1_116ck109 = 0 time = 550
.meas tran vdout1_116ck109 FIND v(dout1_116) AT=550.025n

* CHECK dout1_117 Vdout1_117ck109 = 0.9 time = 550
.meas tran vdout1_117ck109 FIND v(dout1_117) AT=550.025n

* CHECK dout1_118 Vdout1_118ck109 = 0 time = 550
.meas tran vdout1_118ck109 FIND v(dout1_118) AT=550.025n

* CHECK dout1_119 Vdout1_119ck109 = 0.9 time = 550
.meas tran vdout1_119ck109 FIND v(dout1_119) AT=550.025n

* CHECK dout1_0 Vdout1_0ck110 = 0 time = 555
.meas tran vdout1_0ck110 FIND v(dout1_0) AT=555.025n

* CHECK dout1_1 Vdout1_1ck110 = 0 time = 555
.meas tran vdout1_1ck110 FIND v(dout1_1) AT=555.025n

* CHECK dout1_2 Vdout1_2ck110 = 0 time = 555
.meas tran vdout1_2ck110 FIND v(dout1_2) AT=555.025n

* CHECK dout1_3 Vdout1_3ck110 = 0.9 time = 555
.meas tran vdout1_3ck110 FIND v(dout1_3) AT=555.025n

* CHECK dout1_4 Vdout1_4ck110 = 0.9 time = 555
.meas tran vdout1_4ck110 FIND v(dout1_4) AT=555.025n

* CHECK dout1_5 Vdout1_5ck110 = 0 time = 555
.meas tran vdout1_5ck110 FIND v(dout1_5) AT=555.025n

* CHECK dout1_6 Vdout1_6ck110 = 0 time = 555
.meas tran vdout1_6ck110 FIND v(dout1_6) AT=555.025n

* CHECK dout1_7 Vdout1_7ck110 = 0 time = 555
.meas tran vdout1_7ck110 FIND v(dout1_7) AT=555.025n

* CHECK dout1_8 Vdout1_8ck110 = 0 time = 555
.meas tran vdout1_8ck110 FIND v(dout1_8) AT=555.025n

* CHECK dout1_9 Vdout1_9ck110 = 0.9 time = 555
.meas tran vdout1_9ck110 FIND v(dout1_9) AT=555.025n

* CHECK dout1_10 Vdout1_10ck110 = 0 time = 555
.meas tran vdout1_10ck110 FIND v(dout1_10) AT=555.025n

* CHECK dout1_11 Vdout1_11ck110 = 0.9 time = 555
.meas tran vdout1_11ck110 FIND v(dout1_11) AT=555.025n

* CHECK dout1_12 Vdout1_12ck110 = 0 time = 555
.meas tran vdout1_12ck110 FIND v(dout1_12) AT=555.025n

* CHECK dout1_13 Vdout1_13ck110 = 0 time = 555
.meas tran vdout1_13ck110 FIND v(dout1_13) AT=555.025n

* CHECK dout1_14 Vdout1_14ck110 = 0.9 time = 555
.meas tran vdout1_14ck110 FIND v(dout1_14) AT=555.025n

* CHECK dout1_15 Vdout1_15ck110 = 0 time = 555
.meas tran vdout1_15ck110 FIND v(dout1_15) AT=555.025n

* CHECK dout1_16 Vdout1_16ck110 = 0 time = 555
.meas tran vdout1_16ck110 FIND v(dout1_16) AT=555.025n

* CHECK dout1_17 Vdout1_17ck110 = 0.9 time = 555
.meas tran vdout1_17ck110 FIND v(dout1_17) AT=555.025n

* CHECK dout1_18 Vdout1_18ck110 = 0 time = 555
.meas tran vdout1_18ck110 FIND v(dout1_18) AT=555.025n

* CHECK dout1_19 Vdout1_19ck110 = 0 time = 555
.meas tran vdout1_19ck110 FIND v(dout1_19) AT=555.025n

* CHECK dout1_20 Vdout1_20ck110 = 0 time = 555
.meas tran vdout1_20ck110 FIND v(dout1_20) AT=555.025n

* CHECK dout1_21 Vdout1_21ck110 = 0 time = 555
.meas tran vdout1_21ck110 FIND v(dout1_21) AT=555.025n

* CHECK dout1_22 Vdout1_22ck110 = 0 time = 555
.meas tran vdout1_22ck110 FIND v(dout1_22) AT=555.025n

* CHECK dout1_23 Vdout1_23ck110 = 0.9 time = 555
.meas tran vdout1_23ck110 FIND v(dout1_23) AT=555.025n

* CHECK dout1_24 Vdout1_24ck110 = 0 time = 555
.meas tran vdout1_24ck110 FIND v(dout1_24) AT=555.025n

* CHECK dout1_25 Vdout1_25ck110 = 0.9 time = 555
.meas tran vdout1_25ck110 FIND v(dout1_25) AT=555.025n

* CHECK dout1_26 Vdout1_26ck110 = 0 time = 555
.meas tran vdout1_26ck110 FIND v(dout1_26) AT=555.025n

* CHECK dout1_27 Vdout1_27ck110 = 0 time = 555
.meas tran vdout1_27ck110 FIND v(dout1_27) AT=555.025n

* CHECK dout1_28 Vdout1_28ck110 = 0.9 time = 555
.meas tran vdout1_28ck110 FIND v(dout1_28) AT=555.025n

* CHECK dout1_29 Vdout1_29ck110 = 0.9 time = 555
.meas tran vdout1_29ck110 FIND v(dout1_29) AT=555.025n

* CHECK dout1_30 Vdout1_30ck110 = 0 time = 555
.meas tran vdout1_30ck110 FIND v(dout1_30) AT=555.025n

* CHECK dout1_31 Vdout1_31ck110 = 0.9 time = 555
.meas tran vdout1_31ck110 FIND v(dout1_31) AT=555.025n

* CHECK dout1_32 Vdout1_32ck110 = 0 time = 555
.meas tran vdout1_32ck110 FIND v(dout1_32) AT=555.025n

* CHECK dout1_33 Vdout1_33ck110 = 0 time = 555
.meas tran vdout1_33ck110 FIND v(dout1_33) AT=555.025n

* CHECK dout1_34 Vdout1_34ck110 = 0.9 time = 555
.meas tran vdout1_34ck110 FIND v(dout1_34) AT=555.025n

* CHECK dout1_35 Vdout1_35ck110 = 0 time = 555
.meas tran vdout1_35ck110 FIND v(dout1_35) AT=555.025n

* CHECK dout1_36 Vdout1_36ck110 = 0.9 time = 555
.meas tran vdout1_36ck110 FIND v(dout1_36) AT=555.025n

* CHECK dout1_37 Vdout1_37ck110 = 0.9 time = 555
.meas tran vdout1_37ck110 FIND v(dout1_37) AT=555.025n

* CHECK dout1_38 Vdout1_38ck110 = 0.9 time = 555
.meas tran vdout1_38ck110 FIND v(dout1_38) AT=555.025n

* CHECK dout1_39 Vdout1_39ck110 = 0.9 time = 555
.meas tran vdout1_39ck110 FIND v(dout1_39) AT=555.025n

* CHECK dout1_40 Vdout1_40ck110 = 0.9 time = 555
.meas tran vdout1_40ck110 FIND v(dout1_40) AT=555.025n

* CHECK dout1_41 Vdout1_41ck110 = 0 time = 555
.meas tran vdout1_41ck110 FIND v(dout1_41) AT=555.025n

* CHECK dout1_42 Vdout1_42ck110 = 0.9 time = 555
.meas tran vdout1_42ck110 FIND v(dout1_42) AT=555.025n

* CHECK dout1_43 Vdout1_43ck110 = 0.9 time = 555
.meas tran vdout1_43ck110 FIND v(dout1_43) AT=555.025n

* CHECK dout1_44 Vdout1_44ck110 = 0 time = 555
.meas tran vdout1_44ck110 FIND v(dout1_44) AT=555.025n

* CHECK dout1_45 Vdout1_45ck110 = 0 time = 555
.meas tran vdout1_45ck110 FIND v(dout1_45) AT=555.025n

* CHECK dout1_46 Vdout1_46ck110 = 0 time = 555
.meas tran vdout1_46ck110 FIND v(dout1_46) AT=555.025n

* CHECK dout1_47 Vdout1_47ck110 = 0 time = 555
.meas tran vdout1_47ck110 FIND v(dout1_47) AT=555.025n

* CHECK dout1_48 Vdout1_48ck110 = 0.9 time = 555
.meas tran vdout1_48ck110 FIND v(dout1_48) AT=555.025n

* CHECK dout1_49 Vdout1_49ck110 = 0 time = 555
.meas tran vdout1_49ck110 FIND v(dout1_49) AT=555.025n

* CHECK dout1_50 Vdout1_50ck110 = 0.9 time = 555
.meas tran vdout1_50ck110 FIND v(dout1_50) AT=555.025n

* CHECK dout1_51 Vdout1_51ck110 = 0.9 time = 555
.meas tran vdout1_51ck110 FIND v(dout1_51) AT=555.025n

* CHECK dout1_52 Vdout1_52ck110 = 0 time = 555
.meas tran vdout1_52ck110 FIND v(dout1_52) AT=555.025n

* CHECK dout1_53 Vdout1_53ck110 = 0 time = 555
.meas tran vdout1_53ck110 FIND v(dout1_53) AT=555.025n

* CHECK dout1_54 Vdout1_54ck110 = 0 time = 555
.meas tran vdout1_54ck110 FIND v(dout1_54) AT=555.025n

* CHECK dout1_55 Vdout1_55ck110 = 0 time = 555
.meas tran vdout1_55ck110 FIND v(dout1_55) AT=555.025n

* CHECK dout1_56 Vdout1_56ck110 = 0 time = 555
.meas tran vdout1_56ck110 FIND v(dout1_56) AT=555.025n

* CHECK dout1_57 Vdout1_57ck110 = 0 time = 555
.meas tran vdout1_57ck110 FIND v(dout1_57) AT=555.025n

* CHECK dout1_58 Vdout1_58ck110 = 0.9 time = 555
.meas tran vdout1_58ck110 FIND v(dout1_58) AT=555.025n

* CHECK dout1_59 Vdout1_59ck110 = 0.9 time = 555
.meas tran vdout1_59ck110 FIND v(dout1_59) AT=555.025n

* CHECK dout1_60 Vdout1_60ck110 = 0 time = 555
.meas tran vdout1_60ck110 FIND v(dout1_60) AT=555.025n

* CHECK dout1_61 Vdout1_61ck110 = 0.9 time = 555
.meas tran vdout1_61ck110 FIND v(dout1_61) AT=555.025n

* CHECK dout1_62 Vdout1_62ck110 = 0 time = 555
.meas tran vdout1_62ck110 FIND v(dout1_62) AT=555.025n

* CHECK dout1_63 Vdout1_63ck110 = 0.9 time = 555
.meas tran vdout1_63ck110 FIND v(dout1_63) AT=555.025n

* CHECK dout1_64 Vdout1_64ck110 = 0.9 time = 555
.meas tran vdout1_64ck110 FIND v(dout1_64) AT=555.025n

* CHECK dout1_65 Vdout1_65ck110 = 0.9 time = 555
.meas tran vdout1_65ck110 FIND v(dout1_65) AT=555.025n

* CHECK dout1_66 Vdout1_66ck110 = 0.9 time = 555
.meas tran vdout1_66ck110 FIND v(dout1_66) AT=555.025n

* CHECK dout1_67 Vdout1_67ck110 = 0.9 time = 555
.meas tran vdout1_67ck110 FIND v(dout1_67) AT=555.025n

* CHECK dout1_68 Vdout1_68ck110 = 0.9 time = 555
.meas tran vdout1_68ck110 FIND v(dout1_68) AT=555.025n

* CHECK dout1_69 Vdout1_69ck110 = 0 time = 555
.meas tran vdout1_69ck110 FIND v(dout1_69) AT=555.025n

* CHECK dout1_70 Vdout1_70ck110 = 0.9 time = 555
.meas tran vdout1_70ck110 FIND v(dout1_70) AT=555.025n

* CHECK dout1_71 Vdout1_71ck110 = 0.9 time = 555
.meas tran vdout1_71ck110 FIND v(dout1_71) AT=555.025n

* CHECK dout1_72 Vdout1_72ck110 = 0.9 time = 555
.meas tran vdout1_72ck110 FIND v(dout1_72) AT=555.025n

* CHECK dout1_73 Vdout1_73ck110 = 0 time = 555
.meas tran vdout1_73ck110 FIND v(dout1_73) AT=555.025n

* CHECK dout1_74 Vdout1_74ck110 = 0 time = 555
.meas tran vdout1_74ck110 FIND v(dout1_74) AT=555.025n

* CHECK dout1_75 Vdout1_75ck110 = 0.9 time = 555
.meas tran vdout1_75ck110 FIND v(dout1_75) AT=555.025n

* CHECK dout1_76 Vdout1_76ck110 = 0 time = 555
.meas tran vdout1_76ck110 FIND v(dout1_76) AT=555.025n

* CHECK dout1_77 Vdout1_77ck110 = 0.9 time = 555
.meas tran vdout1_77ck110 FIND v(dout1_77) AT=555.025n

* CHECK dout1_78 Vdout1_78ck110 = 0.9 time = 555
.meas tran vdout1_78ck110 FIND v(dout1_78) AT=555.025n

* CHECK dout1_79 Vdout1_79ck110 = 0 time = 555
.meas tran vdout1_79ck110 FIND v(dout1_79) AT=555.025n

* CHECK dout1_80 Vdout1_80ck110 = 0 time = 555
.meas tran vdout1_80ck110 FIND v(dout1_80) AT=555.025n

* CHECK dout1_81 Vdout1_81ck110 = 0 time = 555
.meas tran vdout1_81ck110 FIND v(dout1_81) AT=555.025n

* CHECK dout1_82 Vdout1_82ck110 = 0 time = 555
.meas tran vdout1_82ck110 FIND v(dout1_82) AT=555.025n

* CHECK dout1_83 Vdout1_83ck110 = 0 time = 555
.meas tran vdout1_83ck110 FIND v(dout1_83) AT=555.025n

* CHECK dout1_84 Vdout1_84ck110 = 0 time = 555
.meas tran vdout1_84ck110 FIND v(dout1_84) AT=555.025n

* CHECK dout1_85 Vdout1_85ck110 = 0.9 time = 555
.meas tran vdout1_85ck110 FIND v(dout1_85) AT=555.025n

* CHECK dout1_86 Vdout1_86ck110 = 0.9 time = 555
.meas tran vdout1_86ck110 FIND v(dout1_86) AT=555.025n

* CHECK dout1_87 Vdout1_87ck110 = 0.9 time = 555
.meas tran vdout1_87ck110 FIND v(dout1_87) AT=555.025n

* CHECK dout1_88 Vdout1_88ck110 = 0 time = 555
.meas tran vdout1_88ck110 FIND v(dout1_88) AT=555.025n

* CHECK dout1_89 Vdout1_89ck110 = 0 time = 555
.meas tran vdout1_89ck110 FIND v(dout1_89) AT=555.025n

* CHECK dout1_90 Vdout1_90ck110 = 0.9 time = 555
.meas tran vdout1_90ck110 FIND v(dout1_90) AT=555.025n

* CHECK dout1_91 Vdout1_91ck110 = 0.9 time = 555
.meas tran vdout1_91ck110 FIND v(dout1_91) AT=555.025n

* CHECK dout1_92 Vdout1_92ck110 = 0 time = 555
.meas tran vdout1_92ck110 FIND v(dout1_92) AT=555.025n

* CHECK dout1_93 Vdout1_93ck110 = 0.9 time = 555
.meas tran vdout1_93ck110 FIND v(dout1_93) AT=555.025n

* CHECK dout1_94 Vdout1_94ck110 = 0.9 time = 555
.meas tran vdout1_94ck110 FIND v(dout1_94) AT=555.025n

* CHECK dout1_95 Vdout1_95ck110 = 0.9 time = 555
.meas tran vdout1_95ck110 FIND v(dout1_95) AT=555.025n

* CHECK dout1_96 Vdout1_96ck110 = 0 time = 555
.meas tran vdout1_96ck110 FIND v(dout1_96) AT=555.025n

* CHECK dout1_97 Vdout1_97ck110 = 0 time = 555
.meas tran vdout1_97ck110 FIND v(dout1_97) AT=555.025n

* CHECK dout1_98 Vdout1_98ck110 = 0 time = 555
.meas tran vdout1_98ck110 FIND v(dout1_98) AT=555.025n

* CHECK dout1_99 Vdout1_99ck110 = 0.9 time = 555
.meas tran vdout1_99ck110 FIND v(dout1_99) AT=555.025n

* CHECK dout1_100 Vdout1_100ck110 = 0 time = 555
.meas tran vdout1_100ck110 FIND v(dout1_100) AT=555.025n

* CHECK dout1_101 Vdout1_101ck110 = 0.9 time = 555
.meas tran vdout1_101ck110 FIND v(dout1_101) AT=555.025n

* CHECK dout1_102 Vdout1_102ck110 = 0.9 time = 555
.meas tran vdout1_102ck110 FIND v(dout1_102) AT=555.025n

* CHECK dout1_103 Vdout1_103ck110 = 0 time = 555
.meas tran vdout1_103ck110 FIND v(dout1_103) AT=555.025n

* CHECK dout1_104 Vdout1_104ck110 = 0 time = 555
.meas tran vdout1_104ck110 FIND v(dout1_104) AT=555.025n

* CHECK dout1_105 Vdout1_105ck110 = 0 time = 555
.meas tran vdout1_105ck110 FIND v(dout1_105) AT=555.025n

* CHECK dout1_106 Vdout1_106ck110 = 0 time = 555
.meas tran vdout1_106ck110 FIND v(dout1_106) AT=555.025n

* CHECK dout1_107 Vdout1_107ck110 = 0 time = 555
.meas tran vdout1_107ck110 FIND v(dout1_107) AT=555.025n

* CHECK dout1_108 Vdout1_108ck110 = 0 time = 555
.meas tran vdout1_108ck110 FIND v(dout1_108) AT=555.025n

* CHECK dout1_109 Vdout1_109ck110 = 0.9 time = 555
.meas tran vdout1_109ck110 FIND v(dout1_109) AT=555.025n

* CHECK dout1_110 Vdout1_110ck110 = 0 time = 555
.meas tran vdout1_110ck110 FIND v(dout1_110) AT=555.025n

* CHECK dout1_111 Vdout1_111ck110 = 0.9 time = 555
.meas tran vdout1_111ck110 FIND v(dout1_111) AT=555.025n

* CHECK dout1_112 Vdout1_112ck110 = 0.9 time = 555
.meas tran vdout1_112ck110 FIND v(dout1_112) AT=555.025n

* CHECK dout1_113 Vdout1_113ck110 = 0.9 time = 555
.meas tran vdout1_113ck110 FIND v(dout1_113) AT=555.025n

* CHECK dout1_114 Vdout1_114ck110 = 0 time = 555
.meas tran vdout1_114ck110 FIND v(dout1_114) AT=555.025n

* CHECK dout1_115 Vdout1_115ck110 = 0.9 time = 555
.meas tran vdout1_115ck110 FIND v(dout1_115) AT=555.025n

* CHECK dout1_116 Vdout1_116ck110 = 0 time = 555
.meas tran vdout1_116ck110 FIND v(dout1_116) AT=555.025n

* CHECK dout1_117 Vdout1_117ck110 = 0.9 time = 555
.meas tran vdout1_117ck110 FIND v(dout1_117) AT=555.025n

* CHECK dout1_118 Vdout1_118ck110 = 0 time = 555
.meas tran vdout1_118ck110 FIND v(dout1_118) AT=555.025n

* CHECK dout1_119 Vdout1_119ck110 = 0 time = 555
.meas tran vdout1_119ck110 FIND v(dout1_119) AT=555.025n

* CHECK dout1_0 Vdout1_0ck113 = 0 time = 570
.meas tran vdout1_0ck113 FIND v(dout1_0) AT=570.025n

* CHECK dout1_1 Vdout1_1ck113 = 0.9 time = 570
.meas tran vdout1_1ck113 FIND v(dout1_1) AT=570.025n

* CHECK dout1_2 Vdout1_2ck113 = 0 time = 570
.meas tran vdout1_2ck113 FIND v(dout1_2) AT=570.025n

* CHECK dout1_3 Vdout1_3ck113 = 0 time = 570
.meas tran vdout1_3ck113 FIND v(dout1_3) AT=570.025n

* CHECK dout1_4 Vdout1_4ck113 = 0 time = 570
.meas tran vdout1_4ck113 FIND v(dout1_4) AT=570.025n

* CHECK dout1_5 Vdout1_5ck113 = 0.9 time = 570
.meas tran vdout1_5ck113 FIND v(dout1_5) AT=570.025n

* CHECK dout1_6 Vdout1_6ck113 = 0 time = 570
.meas tran vdout1_6ck113 FIND v(dout1_6) AT=570.025n

* CHECK dout1_7 Vdout1_7ck113 = 0 time = 570
.meas tran vdout1_7ck113 FIND v(dout1_7) AT=570.025n

* CHECK dout1_8 Vdout1_8ck113 = 0.9 time = 570
.meas tran vdout1_8ck113 FIND v(dout1_8) AT=570.025n

* CHECK dout1_9 Vdout1_9ck113 = 0.9 time = 570
.meas tran vdout1_9ck113 FIND v(dout1_9) AT=570.025n

* CHECK dout1_10 Vdout1_10ck113 = 0 time = 570
.meas tran vdout1_10ck113 FIND v(dout1_10) AT=570.025n

* CHECK dout1_11 Vdout1_11ck113 = 0 time = 570
.meas tran vdout1_11ck113 FIND v(dout1_11) AT=570.025n

* CHECK dout1_12 Vdout1_12ck113 = 0 time = 570
.meas tran vdout1_12ck113 FIND v(dout1_12) AT=570.025n

* CHECK dout1_13 Vdout1_13ck113 = 0 time = 570
.meas tran vdout1_13ck113 FIND v(dout1_13) AT=570.025n

* CHECK dout1_14 Vdout1_14ck113 = 0.9 time = 570
.meas tran vdout1_14ck113 FIND v(dout1_14) AT=570.025n

* CHECK dout1_15 Vdout1_15ck113 = 0 time = 570
.meas tran vdout1_15ck113 FIND v(dout1_15) AT=570.025n

* CHECK dout1_16 Vdout1_16ck113 = 0.9 time = 570
.meas tran vdout1_16ck113 FIND v(dout1_16) AT=570.025n

* CHECK dout1_17 Vdout1_17ck113 = 0.9 time = 570
.meas tran vdout1_17ck113 FIND v(dout1_17) AT=570.025n

* CHECK dout1_18 Vdout1_18ck113 = 0 time = 570
.meas tran vdout1_18ck113 FIND v(dout1_18) AT=570.025n

* CHECK dout1_19 Vdout1_19ck113 = 0.9 time = 570
.meas tran vdout1_19ck113 FIND v(dout1_19) AT=570.025n

* CHECK dout1_20 Vdout1_20ck113 = 0.9 time = 570
.meas tran vdout1_20ck113 FIND v(dout1_20) AT=570.025n

* CHECK dout1_21 Vdout1_21ck113 = 0 time = 570
.meas tran vdout1_21ck113 FIND v(dout1_21) AT=570.025n

* CHECK dout1_22 Vdout1_22ck113 = 0.9 time = 570
.meas tran vdout1_22ck113 FIND v(dout1_22) AT=570.025n

* CHECK dout1_23 Vdout1_23ck113 = 0.9 time = 570
.meas tran vdout1_23ck113 FIND v(dout1_23) AT=570.025n

* CHECK dout1_24 Vdout1_24ck113 = 0.9 time = 570
.meas tran vdout1_24ck113 FIND v(dout1_24) AT=570.025n

* CHECK dout1_25 Vdout1_25ck113 = 0 time = 570
.meas tran vdout1_25ck113 FIND v(dout1_25) AT=570.025n

* CHECK dout1_26 Vdout1_26ck113 = 0.9 time = 570
.meas tran vdout1_26ck113 FIND v(dout1_26) AT=570.025n

* CHECK dout1_27 Vdout1_27ck113 = 0 time = 570
.meas tran vdout1_27ck113 FIND v(dout1_27) AT=570.025n

* CHECK dout1_28 Vdout1_28ck113 = 0 time = 570
.meas tran vdout1_28ck113 FIND v(dout1_28) AT=570.025n

* CHECK dout1_29 Vdout1_29ck113 = 0 time = 570
.meas tran vdout1_29ck113 FIND v(dout1_29) AT=570.025n

* CHECK dout1_30 Vdout1_30ck113 = 0 time = 570
.meas tran vdout1_30ck113 FIND v(dout1_30) AT=570.025n

* CHECK dout1_31 Vdout1_31ck113 = 0 time = 570
.meas tran vdout1_31ck113 FIND v(dout1_31) AT=570.025n

* CHECK dout1_32 Vdout1_32ck113 = 0.9 time = 570
.meas tran vdout1_32ck113 FIND v(dout1_32) AT=570.025n

* CHECK dout1_33 Vdout1_33ck113 = 0.9 time = 570
.meas tran vdout1_33ck113 FIND v(dout1_33) AT=570.025n

* CHECK dout1_34 Vdout1_34ck113 = 0 time = 570
.meas tran vdout1_34ck113 FIND v(dout1_34) AT=570.025n

* CHECK dout1_35 Vdout1_35ck113 = 0 time = 570
.meas tran vdout1_35ck113 FIND v(dout1_35) AT=570.025n

* CHECK dout1_36 Vdout1_36ck113 = 0 time = 570
.meas tran vdout1_36ck113 FIND v(dout1_36) AT=570.025n

* CHECK dout1_37 Vdout1_37ck113 = 0 time = 570
.meas tran vdout1_37ck113 FIND v(dout1_37) AT=570.025n

* CHECK dout1_38 Vdout1_38ck113 = 0.9 time = 570
.meas tran vdout1_38ck113 FIND v(dout1_38) AT=570.025n

* CHECK dout1_39 Vdout1_39ck113 = 0.9 time = 570
.meas tran vdout1_39ck113 FIND v(dout1_39) AT=570.025n

* CHECK dout1_40 Vdout1_40ck113 = 0.9 time = 570
.meas tran vdout1_40ck113 FIND v(dout1_40) AT=570.025n

* CHECK dout1_41 Vdout1_41ck113 = 0 time = 570
.meas tran vdout1_41ck113 FIND v(dout1_41) AT=570.025n

* CHECK dout1_42 Vdout1_42ck113 = 0 time = 570
.meas tran vdout1_42ck113 FIND v(dout1_42) AT=570.025n

* CHECK dout1_43 Vdout1_43ck113 = 0 time = 570
.meas tran vdout1_43ck113 FIND v(dout1_43) AT=570.025n

* CHECK dout1_44 Vdout1_44ck113 = 0.9 time = 570
.meas tran vdout1_44ck113 FIND v(dout1_44) AT=570.025n

* CHECK dout1_45 Vdout1_45ck113 = 0 time = 570
.meas tran vdout1_45ck113 FIND v(dout1_45) AT=570.025n

* CHECK dout1_46 Vdout1_46ck113 = 0.9 time = 570
.meas tran vdout1_46ck113 FIND v(dout1_46) AT=570.025n

* CHECK dout1_47 Vdout1_47ck113 = 0.9 time = 570
.meas tran vdout1_47ck113 FIND v(dout1_47) AT=570.025n

* CHECK dout1_48 Vdout1_48ck113 = 0 time = 570
.meas tran vdout1_48ck113 FIND v(dout1_48) AT=570.025n

* CHECK dout1_49 Vdout1_49ck113 = 0.9 time = 570
.meas tran vdout1_49ck113 FIND v(dout1_49) AT=570.025n

* CHECK dout1_50 Vdout1_50ck113 = 0.9 time = 570
.meas tran vdout1_50ck113 FIND v(dout1_50) AT=570.025n

* CHECK dout1_51 Vdout1_51ck113 = 0.9 time = 570
.meas tran vdout1_51ck113 FIND v(dout1_51) AT=570.025n

* CHECK dout1_52 Vdout1_52ck113 = 0.9 time = 570
.meas tran vdout1_52ck113 FIND v(dout1_52) AT=570.025n

* CHECK dout1_53 Vdout1_53ck113 = 0.9 time = 570
.meas tran vdout1_53ck113 FIND v(dout1_53) AT=570.025n

* CHECK dout1_54 Vdout1_54ck113 = 0 time = 570
.meas tran vdout1_54ck113 FIND v(dout1_54) AT=570.025n

* CHECK dout1_55 Vdout1_55ck113 = 0 time = 570
.meas tran vdout1_55ck113 FIND v(dout1_55) AT=570.025n

* CHECK dout1_56 Vdout1_56ck113 = 0 time = 570
.meas tran vdout1_56ck113 FIND v(dout1_56) AT=570.025n

* CHECK dout1_57 Vdout1_57ck113 = 0.9 time = 570
.meas tran vdout1_57ck113 FIND v(dout1_57) AT=570.025n

* CHECK dout1_58 Vdout1_58ck113 = 0.9 time = 570
.meas tran vdout1_58ck113 FIND v(dout1_58) AT=570.025n

* CHECK dout1_59 Vdout1_59ck113 = 0.9 time = 570
.meas tran vdout1_59ck113 FIND v(dout1_59) AT=570.025n

* CHECK dout1_60 Vdout1_60ck113 = 0 time = 570
.meas tran vdout1_60ck113 FIND v(dout1_60) AT=570.025n

* CHECK dout1_61 Vdout1_61ck113 = 0.9 time = 570
.meas tran vdout1_61ck113 FIND v(dout1_61) AT=570.025n

* CHECK dout1_62 Vdout1_62ck113 = 0 time = 570
.meas tran vdout1_62ck113 FIND v(dout1_62) AT=570.025n

* CHECK dout1_63 Vdout1_63ck113 = 0 time = 570
.meas tran vdout1_63ck113 FIND v(dout1_63) AT=570.025n

* CHECK dout1_64 Vdout1_64ck113 = 0.9 time = 570
.meas tran vdout1_64ck113 FIND v(dout1_64) AT=570.025n

* CHECK dout1_65 Vdout1_65ck113 = 0 time = 570
.meas tran vdout1_65ck113 FIND v(dout1_65) AT=570.025n

* CHECK dout1_66 Vdout1_66ck113 = 0 time = 570
.meas tran vdout1_66ck113 FIND v(dout1_66) AT=570.025n

* CHECK dout1_67 Vdout1_67ck113 = 0 time = 570
.meas tran vdout1_67ck113 FIND v(dout1_67) AT=570.025n

* CHECK dout1_68 Vdout1_68ck113 = 0.9 time = 570
.meas tran vdout1_68ck113 FIND v(dout1_68) AT=570.025n

* CHECK dout1_69 Vdout1_69ck113 = 0 time = 570
.meas tran vdout1_69ck113 FIND v(dout1_69) AT=570.025n

* CHECK dout1_70 Vdout1_70ck113 = 0.9 time = 570
.meas tran vdout1_70ck113 FIND v(dout1_70) AT=570.025n

* CHECK dout1_71 Vdout1_71ck113 = 0.9 time = 570
.meas tran vdout1_71ck113 FIND v(dout1_71) AT=570.025n

* CHECK dout1_72 Vdout1_72ck113 = 0.9 time = 570
.meas tran vdout1_72ck113 FIND v(dout1_72) AT=570.025n

* CHECK dout1_73 Vdout1_73ck113 = 0.9 time = 570
.meas tran vdout1_73ck113 FIND v(dout1_73) AT=570.025n

* CHECK dout1_74 Vdout1_74ck113 = 0 time = 570
.meas tran vdout1_74ck113 FIND v(dout1_74) AT=570.025n

* CHECK dout1_75 Vdout1_75ck113 = 0.9 time = 570
.meas tran vdout1_75ck113 FIND v(dout1_75) AT=570.025n

* CHECK dout1_76 Vdout1_76ck113 = 0.9 time = 570
.meas tran vdout1_76ck113 FIND v(dout1_76) AT=570.025n

* CHECK dout1_77 Vdout1_77ck113 = 0.9 time = 570
.meas tran vdout1_77ck113 FIND v(dout1_77) AT=570.025n

* CHECK dout1_78 Vdout1_78ck113 = 0.9 time = 570
.meas tran vdout1_78ck113 FIND v(dout1_78) AT=570.025n

* CHECK dout1_79 Vdout1_79ck113 = 0.9 time = 570
.meas tran vdout1_79ck113 FIND v(dout1_79) AT=570.025n

* CHECK dout1_80 Vdout1_80ck113 = 0.9 time = 570
.meas tran vdout1_80ck113 FIND v(dout1_80) AT=570.025n

* CHECK dout1_81 Vdout1_81ck113 = 0.9 time = 570
.meas tran vdout1_81ck113 FIND v(dout1_81) AT=570.025n

* CHECK dout1_82 Vdout1_82ck113 = 0 time = 570
.meas tran vdout1_82ck113 FIND v(dout1_82) AT=570.025n

* CHECK dout1_83 Vdout1_83ck113 = 0 time = 570
.meas tran vdout1_83ck113 FIND v(dout1_83) AT=570.025n

* CHECK dout1_84 Vdout1_84ck113 = 0 time = 570
.meas tran vdout1_84ck113 FIND v(dout1_84) AT=570.025n

* CHECK dout1_85 Vdout1_85ck113 = 0.9 time = 570
.meas tran vdout1_85ck113 FIND v(dout1_85) AT=570.025n

* CHECK dout1_86 Vdout1_86ck113 = 0.9 time = 570
.meas tran vdout1_86ck113 FIND v(dout1_86) AT=570.025n

* CHECK dout1_87 Vdout1_87ck113 = 0 time = 570
.meas tran vdout1_87ck113 FIND v(dout1_87) AT=570.025n

* CHECK dout1_88 Vdout1_88ck113 = 0.9 time = 570
.meas tran vdout1_88ck113 FIND v(dout1_88) AT=570.025n

* CHECK dout1_89 Vdout1_89ck113 = 0.9 time = 570
.meas tran vdout1_89ck113 FIND v(dout1_89) AT=570.025n

* CHECK dout1_90 Vdout1_90ck113 = 0 time = 570
.meas tran vdout1_90ck113 FIND v(dout1_90) AT=570.025n

* CHECK dout1_91 Vdout1_91ck113 = 0 time = 570
.meas tran vdout1_91ck113 FIND v(dout1_91) AT=570.025n

* CHECK dout1_92 Vdout1_92ck113 = 0.9 time = 570
.meas tran vdout1_92ck113 FIND v(dout1_92) AT=570.025n

* CHECK dout1_93 Vdout1_93ck113 = 0 time = 570
.meas tran vdout1_93ck113 FIND v(dout1_93) AT=570.025n

* CHECK dout1_94 Vdout1_94ck113 = 0.9 time = 570
.meas tran vdout1_94ck113 FIND v(dout1_94) AT=570.025n

* CHECK dout1_95 Vdout1_95ck113 = 0 time = 570
.meas tran vdout1_95ck113 FIND v(dout1_95) AT=570.025n

* CHECK dout1_96 Vdout1_96ck113 = 0.9 time = 570
.meas tran vdout1_96ck113 FIND v(dout1_96) AT=570.025n

* CHECK dout1_97 Vdout1_97ck113 = 0.9 time = 570
.meas tran vdout1_97ck113 FIND v(dout1_97) AT=570.025n

* CHECK dout1_98 Vdout1_98ck113 = 0 time = 570
.meas tran vdout1_98ck113 FIND v(dout1_98) AT=570.025n

* CHECK dout1_99 Vdout1_99ck113 = 0 time = 570
.meas tran vdout1_99ck113 FIND v(dout1_99) AT=570.025n

* CHECK dout1_100 Vdout1_100ck113 = 0 time = 570
.meas tran vdout1_100ck113 FIND v(dout1_100) AT=570.025n

* CHECK dout1_101 Vdout1_101ck113 = 0 time = 570
.meas tran vdout1_101ck113 FIND v(dout1_101) AT=570.025n

* CHECK dout1_102 Vdout1_102ck113 = 0.9 time = 570
.meas tran vdout1_102ck113 FIND v(dout1_102) AT=570.025n

* CHECK dout1_103 Vdout1_103ck113 = 0 time = 570
.meas tran vdout1_103ck113 FIND v(dout1_103) AT=570.025n

* CHECK dout1_104 Vdout1_104ck113 = 0.9 time = 570
.meas tran vdout1_104ck113 FIND v(dout1_104) AT=570.025n

* CHECK dout1_105 Vdout1_105ck113 = 0 time = 570
.meas tran vdout1_105ck113 FIND v(dout1_105) AT=570.025n

* CHECK dout1_106 Vdout1_106ck113 = 0 time = 570
.meas tran vdout1_106ck113 FIND v(dout1_106) AT=570.025n

* CHECK dout1_107 Vdout1_107ck113 = 0.9 time = 570
.meas tran vdout1_107ck113 FIND v(dout1_107) AT=570.025n

* CHECK dout1_108 Vdout1_108ck113 = 0.9 time = 570
.meas tran vdout1_108ck113 FIND v(dout1_108) AT=570.025n

* CHECK dout1_109 Vdout1_109ck113 = 0.9 time = 570
.meas tran vdout1_109ck113 FIND v(dout1_109) AT=570.025n

* CHECK dout1_110 Vdout1_110ck113 = 0 time = 570
.meas tran vdout1_110ck113 FIND v(dout1_110) AT=570.025n

* CHECK dout1_111 Vdout1_111ck113 = 0.9 time = 570
.meas tran vdout1_111ck113 FIND v(dout1_111) AT=570.025n

* CHECK dout1_112 Vdout1_112ck113 = 0.9 time = 570
.meas tran vdout1_112ck113 FIND v(dout1_112) AT=570.025n

* CHECK dout1_113 Vdout1_113ck113 = 0.9 time = 570
.meas tran vdout1_113ck113 FIND v(dout1_113) AT=570.025n

* CHECK dout1_114 Vdout1_114ck113 = 0.9 time = 570
.meas tran vdout1_114ck113 FIND v(dout1_114) AT=570.025n

* CHECK dout1_115 Vdout1_115ck113 = 0 time = 570
.meas tran vdout1_115ck113 FIND v(dout1_115) AT=570.025n

* CHECK dout1_116 Vdout1_116ck113 = 0 time = 570
.meas tran vdout1_116ck113 FIND v(dout1_116) AT=570.025n

* CHECK dout1_117 Vdout1_117ck113 = 0.9 time = 570
.meas tran vdout1_117ck113 FIND v(dout1_117) AT=570.025n

* CHECK dout1_118 Vdout1_118ck113 = 0 time = 570
.meas tran vdout1_118ck113 FIND v(dout1_118) AT=570.025n

* CHECK dout1_119 Vdout1_119ck113 = 0.9 time = 570
.meas tran vdout1_119ck113 FIND v(dout1_119) AT=570.025n

* CHECK dout1_0 Vdout1_0ck114 = 0 time = 575
.meas tran vdout1_0ck114 FIND v(dout1_0) AT=575.025n

* CHECK dout1_1 Vdout1_1ck114 = 0.9 time = 575
.meas tran vdout1_1ck114 FIND v(dout1_1) AT=575.025n

* CHECK dout1_2 Vdout1_2ck114 = 0 time = 575
.meas tran vdout1_2ck114 FIND v(dout1_2) AT=575.025n

* CHECK dout1_3 Vdout1_3ck114 = 0 time = 575
.meas tran vdout1_3ck114 FIND v(dout1_3) AT=575.025n

* CHECK dout1_4 Vdout1_4ck114 = 0 time = 575
.meas tran vdout1_4ck114 FIND v(dout1_4) AT=575.025n

* CHECK dout1_5 Vdout1_5ck114 = 0.9 time = 575
.meas tran vdout1_5ck114 FIND v(dout1_5) AT=575.025n

* CHECK dout1_6 Vdout1_6ck114 = 0 time = 575
.meas tran vdout1_6ck114 FIND v(dout1_6) AT=575.025n

* CHECK dout1_7 Vdout1_7ck114 = 0 time = 575
.meas tran vdout1_7ck114 FIND v(dout1_7) AT=575.025n

* CHECK dout1_8 Vdout1_8ck114 = 0.9 time = 575
.meas tran vdout1_8ck114 FIND v(dout1_8) AT=575.025n

* CHECK dout1_9 Vdout1_9ck114 = 0.9 time = 575
.meas tran vdout1_9ck114 FIND v(dout1_9) AT=575.025n

* CHECK dout1_10 Vdout1_10ck114 = 0 time = 575
.meas tran vdout1_10ck114 FIND v(dout1_10) AT=575.025n

* CHECK dout1_11 Vdout1_11ck114 = 0 time = 575
.meas tran vdout1_11ck114 FIND v(dout1_11) AT=575.025n

* CHECK dout1_12 Vdout1_12ck114 = 0 time = 575
.meas tran vdout1_12ck114 FIND v(dout1_12) AT=575.025n

* CHECK dout1_13 Vdout1_13ck114 = 0 time = 575
.meas tran vdout1_13ck114 FIND v(dout1_13) AT=575.025n

* CHECK dout1_14 Vdout1_14ck114 = 0.9 time = 575
.meas tran vdout1_14ck114 FIND v(dout1_14) AT=575.025n

* CHECK dout1_15 Vdout1_15ck114 = 0 time = 575
.meas tran vdout1_15ck114 FIND v(dout1_15) AT=575.025n

* CHECK dout1_16 Vdout1_16ck114 = 0.9 time = 575
.meas tran vdout1_16ck114 FIND v(dout1_16) AT=575.025n

* CHECK dout1_17 Vdout1_17ck114 = 0.9 time = 575
.meas tran vdout1_17ck114 FIND v(dout1_17) AT=575.025n

* CHECK dout1_18 Vdout1_18ck114 = 0 time = 575
.meas tran vdout1_18ck114 FIND v(dout1_18) AT=575.025n

* CHECK dout1_19 Vdout1_19ck114 = 0.9 time = 575
.meas tran vdout1_19ck114 FIND v(dout1_19) AT=575.025n

* CHECK dout1_20 Vdout1_20ck114 = 0.9 time = 575
.meas tran vdout1_20ck114 FIND v(dout1_20) AT=575.025n

* CHECK dout1_21 Vdout1_21ck114 = 0 time = 575
.meas tran vdout1_21ck114 FIND v(dout1_21) AT=575.025n

* CHECK dout1_22 Vdout1_22ck114 = 0.9 time = 575
.meas tran vdout1_22ck114 FIND v(dout1_22) AT=575.025n

* CHECK dout1_23 Vdout1_23ck114 = 0.9 time = 575
.meas tran vdout1_23ck114 FIND v(dout1_23) AT=575.025n

* CHECK dout1_24 Vdout1_24ck114 = 0.9 time = 575
.meas tran vdout1_24ck114 FIND v(dout1_24) AT=575.025n

* CHECK dout1_25 Vdout1_25ck114 = 0 time = 575
.meas tran vdout1_25ck114 FIND v(dout1_25) AT=575.025n

* CHECK dout1_26 Vdout1_26ck114 = 0.9 time = 575
.meas tran vdout1_26ck114 FIND v(dout1_26) AT=575.025n

* CHECK dout1_27 Vdout1_27ck114 = 0 time = 575
.meas tran vdout1_27ck114 FIND v(dout1_27) AT=575.025n

* CHECK dout1_28 Vdout1_28ck114 = 0 time = 575
.meas tran vdout1_28ck114 FIND v(dout1_28) AT=575.025n

* CHECK dout1_29 Vdout1_29ck114 = 0 time = 575
.meas tran vdout1_29ck114 FIND v(dout1_29) AT=575.025n

* CHECK dout1_30 Vdout1_30ck114 = 0 time = 575
.meas tran vdout1_30ck114 FIND v(dout1_30) AT=575.025n

* CHECK dout1_31 Vdout1_31ck114 = 0 time = 575
.meas tran vdout1_31ck114 FIND v(dout1_31) AT=575.025n

* CHECK dout1_32 Vdout1_32ck114 = 0.9 time = 575
.meas tran vdout1_32ck114 FIND v(dout1_32) AT=575.025n

* CHECK dout1_33 Vdout1_33ck114 = 0.9 time = 575
.meas tran vdout1_33ck114 FIND v(dout1_33) AT=575.025n

* CHECK dout1_34 Vdout1_34ck114 = 0 time = 575
.meas tran vdout1_34ck114 FIND v(dout1_34) AT=575.025n

* CHECK dout1_35 Vdout1_35ck114 = 0 time = 575
.meas tran vdout1_35ck114 FIND v(dout1_35) AT=575.025n

* CHECK dout1_36 Vdout1_36ck114 = 0 time = 575
.meas tran vdout1_36ck114 FIND v(dout1_36) AT=575.025n

* CHECK dout1_37 Vdout1_37ck114 = 0 time = 575
.meas tran vdout1_37ck114 FIND v(dout1_37) AT=575.025n

* CHECK dout1_38 Vdout1_38ck114 = 0.9 time = 575
.meas tran vdout1_38ck114 FIND v(dout1_38) AT=575.025n

* CHECK dout1_39 Vdout1_39ck114 = 0.9 time = 575
.meas tran vdout1_39ck114 FIND v(dout1_39) AT=575.025n

* CHECK dout1_40 Vdout1_40ck114 = 0.9 time = 575
.meas tran vdout1_40ck114 FIND v(dout1_40) AT=575.025n

* CHECK dout1_41 Vdout1_41ck114 = 0 time = 575
.meas tran vdout1_41ck114 FIND v(dout1_41) AT=575.025n

* CHECK dout1_42 Vdout1_42ck114 = 0 time = 575
.meas tran vdout1_42ck114 FIND v(dout1_42) AT=575.025n

* CHECK dout1_43 Vdout1_43ck114 = 0 time = 575
.meas tran vdout1_43ck114 FIND v(dout1_43) AT=575.025n

* CHECK dout1_44 Vdout1_44ck114 = 0.9 time = 575
.meas tran vdout1_44ck114 FIND v(dout1_44) AT=575.025n

* CHECK dout1_45 Vdout1_45ck114 = 0 time = 575
.meas tran vdout1_45ck114 FIND v(dout1_45) AT=575.025n

* CHECK dout1_46 Vdout1_46ck114 = 0.9 time = 575
.meas tran vdout1_46ck114 FIND v(dout1_46) AT=575.025n

* CHECK dout1_47 Vdout1_47ck114 = 0.9 time = 575
.meas tran vdout1_47ck114 FIND v(dout1_47) AT=575.025n

* CHECK dout1_48 Vdout1_48ck114 = 0 time = 575
.meas tran vdout1_48ck114 FIND v(dout1_48) AT=575.025n

* CHECK dout1_49 Vdout1_49ck114 = 0.9 time = 575
.meas tran vdout1_49ck114 FIND v(dout1_49) AT=575.025n

* CHECK dout1_50 Vdout1_50ck114 = 0.9 time = 575
.meas tran vdout1_50ck114 FIND v(dout1_50) AT=575.025n

* CHECK dout1_51 Vdout1_51ck114 = 0.9 time = 575
.meas tran vdout1_51ck114 FIND v(dout1_51) AT=575.025n

* CHECK dout1_52 Vdout1_52ck114 = 0.9 time = 575
.meas tran vdout1_52ck114 FIND v(dout1_52) AT=575.025n

* CHECK dout1_53 Vdout1_53ck114 = 0.9 time = 575
.meas tran vdout1_53ck114 FIND v(dout1_53) AT=575.025n

* CHECK dout1_54 Vdout1_54ck114 = 0 time = 575
.meas tran vdout1_54ck114 FIND v(dout1_54) AT=575.025n

* CHECK dout1_55 Vdout1_55ck114 = 0 time = 575
.meas tran vdout1_55ck114 FIND v(dout1_55) AT=575.025n

* CHECK dout1_56 Vdout1_56ck114 = 0 time = 575
.meas tran vdout1_56ck114 FIND v(dout1_56) AT=575.025n

* CHECK dout1_57 Vdout1_57ck114 = 0.9 time = 575
.meas tran vdout1_57ck114 FIND v(dout1_57) AT=575.025n

* CHECK dout1_58 Vdout1_58ck114 = 0.9 time = 575
.meas tran vdout1_58ck114 FIND v(dout1_58) AT=575.025n

* CHECK dout1_59 Vdout1_59ck114 = 0.9 time = 575
.meas tran vdout1_59ck114 FIND v(dout1_59) AT=575.025n

* CHECK dout1_60 Vdout1_60ck114 = 0 time = 575
.meas tran vdout1_60ck114 FIND v(dout1_60) AT=575.025n

* CHECK dout1_61 Vdout1_61ck114 = 0.9 time = 575
.meas tran vdout1_61ck114 FIND v(dout1_61) AT=575.025n

* CHECK dout1_62 Vdout1_62ck114 = 0 time = 575
.meas tran vdout1_62ck114 FIND v(dout1_62) AT=575.025n

* CHECK dout1_63 Vdout1_63ck114 = 0 time = 575
.meas tran vdout1_63ck114 FIND v(dout1_63) AT=575.025n

* CHECK dout1_64 Vdout1_64ck114 = 0.9 time = 575
.meas tran vdout1_64ck114 FIND v(dout1_64) AT=575.025n

* CHECK dout1_65 Vdout1_65ck114 = 0 time = 575
.meas tran vdout1_65ck114 FIND v(dout1_65) AT=575.025n

* CHECK dout1_66 Vdout1_66ck114 = 0 time = 575
.meas tran vdout1_66ck114 FIND v(dout1_66) AT=575.025n

* CHECK dout1_67 Vdout1_67ck114 = 0 time = 575
.meas tran vdout1_67ck114 FIND v(dout1_67) AT=575.025n

* CHECK dout1_68 Vdout1_68ck114 = 0.9 time = 575
.meas tran vdout1_68ck114 FIND v(dout1_68) AT=575.025n

* CHECK dout1_69 Vdout1_69ck114 = 0 time = 575
.meas tran vdout1_69ck114 FIND v(dout1_69) AT=575.025n

* CHECK dout1_70 Vdout1_70ck114 = 0.9 time = 575
.meas tran vdout1_70ck114 FIND v(dout1_70) AT=575.025n

* CHECK dout1_71 Vdout1_71ck114 = 0.9 time = 575
.meas tran vdout1_71ck114 FIND v(dout1_71) AT=575.025n

* CHECK dout1_72 Vdout1_72ck114 = 0.9 time = 575
.meas tran vdout1_72ck114 FIND v(dout1_72) AT=575.025n

* CHECK dout1_73 Vdout1_73ck114 = 0.9 time = 575
.meas tran vdout1_73ck114 FIND v(dout1_73) AT=575.025n

* CHECK dout1_74 Vdout1_74ck114 = 0 time = 575
.meas tran vdout1_74ck114 FIND v(dout1_74) AT=575.025n

* CHECK dout1_75 Vdout1_75ck114 = 0.9 time = 575
.meas tran vdout1_75ck114 FIND v(dout1_75) AT=575.025n

* CHECK dout1_76 Vdout1_76ck114 = 0.9 time = 575
.meas tran vdout1_76ck114 FIND v(dout1_76) AT=575.025n

* CHECK dout1_77 Vdout1_77ck114 = 0.9 time = 575
.meas tran vdout1_77ck114 FIND v(dout1_77) AT=575.025n

* CHECK dout1_78 Vdout1_78ck114 = 0.9 time = 575
.meas tran vdout1_78ck114 FIND v(dout1_78) AT=575.025n

* CHECK dout1_79 Vdout1_79ck114 = 0.9 time = 575
.meas tran vdout1_79ck114 FIND v(dout1_79) AT=575.025n

* CHECK dout1_80 Vdout1_80ck114 = 0.9 time = 575
.meas tran vdout1_80ck114 FIND v(dout1_80) AT=575.025n

* CHECK dout1_81 Vdout1_81ck114 = 0.9 time = 575
.meas tran vdout1_81ck114 FIND v(dout1_81) AT=575.025n

* CHECK dout1_82 Vdout1_82ck114 = 0 time = 575
.meas tran vdout1_82ck114 FIND v(dout1_82) AT=575.025n

* CHECK dout1_83 Vdout1_83ck114 = 0 time = 575
.meas tran vdout1_83ck114 FIND v(dout1_83) AT=575.025n

* CHECK dout1_84 Vdout1_84ck114 = 0 time = 575
.meas tran vdout1_84ck114 FIND v(dout1_84) AT=575.025n

* CHECK dout1_85 Vdout1_85ck114 = 0.9 time = 575
.meas tran vdout1_85ck114 FIND v(dout1_85) AT=575.025n

* CHECK dout1_86 Vdout1_86ck114 = 0.9 time = 575
.meas tran vdout1_86ck114 FIND v(dout1_86) AT=575.025n

* CHECK dout1_87 Vdout1_87ck114 = 0 time = 575
.meas tran vdout1_87ck114 FIND v(dout1_87) AT=575.025n

* CHECK dout1_88 Vdout1_88ck114 = 0.9 time = 575
.meas tran vdout1_88ck114 FIND v(dout1_88) AT=575.025n

* CHECK dout1_89 Vdout1_89ck114 = 0.9 time = 575
.meas tran vdout1_89ck114 FIND v(dout1_89) AT=575.025n

* CHECK dout1_90 Vdout1_90ck114 = 0 time = 575
.meas tran vdout1_90ck114 FIND v(dout1_90) AT=575.025n

* CHECK dout1_91 Vdout1_91ck114 = 0 time = 575
.meas tran vdout1_91ck114 FIND v(dout1_91) AT=575.025n

* CHECK dout1_92 Vdout1_92ck114 = 0.9 time = 575
.meas tran vdout1_92ck114 FIND v(dout1_92) AT=575.025n

* CHECK dout1_93 Vdout1_93ck114 = 0 time = 575
.meas tran vdout1_93ck114 FIND v(dout1_93) AT=575.025n

* CHECK dout1_94 Vdout1_94ck114 = 0.9 time = 575
.meas tran vdout1_94ck114 FIND v(dout1_94) AT=575.025n

* CHECK dout1_95 Vdout1_95ck114 = 0 time = 575
.meas tran vdout1_95ck114 FIND v(dout1_95) AT=575.025n

* CHECK dout1_96 Vdout1_96ck114 = 0.9 time = 575
.meas tran vdout1_96ck114 FIND v(dout1_96) AT=575.025n

* CHECK dout1_97 Vdout1_97ck114 = 0.9 time = 575
.meas tran vdout1_97ck114 FIND v(dout1_97) AT=575.025n

* CHECK dout1_98 Vdout1_98ck114 = 0 time = 575
.meas tran vdout1_98ck114 FIND v(dout1_98) AT=575.025n

* CHECK dout1_99 Vdout1_99ck114 = 0 time = 575
.meas tran vdout1_99ck114 FIND v(dout1_99) AT=575.025n

* CHECK dout1_100 Vdout1_100ck114 = 0 time = 575
.meas tran vdout1_100ck114 FIND v(dout1_100) AT=575.025n

* CHECK dout1_101 Vdout1_101ck114 = 0 time = 575
.meas tran vdout1_101ck114 FIND v(dout1_101) AT=575.025n

* CHECK dout1_102 Vdout1_102ck114 = 0.9 time = 575
.meas tran vdout1_102ck114 FIND v(dout1_102) AT=575.025n

* CHECK dout1_103 Vdout1_103ck114 = 0 time = 575
.meas tran vdout1_103ck114 FIND v(dout1_103) AT=575.025n

* CHECK dout1_104 Vdout1_104ck114 = 0.9 time = 575
.meas tran vdout1_104ck114 FIND v(dout1_104) AT=575.025n

* CHECK dout1_105 Vdout1_105ck114 = 0 time = 575
.meas tran vdout1_105ck114 FIND v(dout1_105) AT=575.025n

* CHECK dout1_106 Vdout1_106ck114 = 0 time = 575
.meas tran vdout1_106ck114 FIND v(dout1_106) AT=575.025n

* CHECK dout1_107 Vdout1_107ck114 = 0.9 time = 575
.meas tran vdout1_107ck114 FIND v(dout1_107) AT=575.025n

* CHECK dout1_108 Vdout1_108ck114 = 0.9 time = 575
.meas tran vdout1_108ck114 FIND v(dout1_108) AT=575.025n

* CHECK dout1_109 Vdout1_109ck114 = 0.9 time = 575
.meas tran vdout1_109ck114 FIND v(dout1_109) AT=575.025n

* CHECK dout1_110 Vdout1_110ck114 = 0 time = 575
.meas tran vdout1_110ck114 FIND v(dout1_110) AT=575.025n

* CHECK dout1_111 Vdout1_111ck114 = 0.9 time = 575
.meas tran vdout1_111ck114 FIND v(dout1_111) AT=575.025n

* CHECK dout1_112 Vdout1_112ck114 = 0.9 time = 575
.meas tran vdout1_112ck114 FIND v(dout1_112) AT=575.025n

* CHECK dout1_113 Vdout1_113ck114 = 0.9 time = 575
.meas tran vdout1_113ck114 FIND v(dout1_113) AT=575.025n

* CHECK dout1_114 Vdout1_114ck114 = 0.9 time = 575
.meas tran vdout1_114ck114 FIND v(dout1_114) AT=575.025n

* CHECK dout1_115 Vdout1_115ck114 = 0 time = 575
.meas tran vdout1_115ck114 FIND v(dout1_115) AT=575.025n

* CHECK dout1_116 Vdout1_116ck114 = 0 time = 575
.meas tran vdout1_116ck114 FIND v(dout1_116) AT=575.025n

* CHECK dout1_117 Vdout1_117ck114 = 0.9 time = 575
.meas tran vdout1_117ck114 FIND v(dout1_117) AT=575.025n

* CHECK dout1_118 Vdout1_118ck114 = 0 time = 575
.meas tran vdout1_118ck114 FIND v(dout1_118) AT=575.025n

* CHECK dout1_119 Vdout1_119ck114 = 0.9 time = 575
.meas tran vdout1_119ck114 FIND v(dout1_119) AT=575.025n

* CHECK dout1_0 Vdout1_0ck116 = 0 time = 585
.meas tran vdout1_0ck116 FIND v(dout1_0) AT=585.025n

* CHECK dout1_1 Vdout1_1ck116 = 0.9 time = 585
.meas tran vdout1_1ck116 FIND v(dout1_1) AT=585.025n

* CHECK dout1_2 Vdout1_2ck116 = 0 time = 585
.meas tran vdout1_2ck116 FIND v(dout1_2) AT=585.025n

* CHECK dout1_3 Vdout1_3ck116 = 0 time = 585
.meas tran vdout1_3ck116 FIND v(dout1_3) AT=585.025n

* CHECK dout1_4 Vdout1_4ck116 = 0 time = 585
.meas tran vdout1_4ck116 FIND v(dout1_4) AT=585.025n

* CHECK dout1_5 Vdout1_5ck116 = 0.9 time = 585
.meas tran vdout1_5ck116 FIND v(dout1_5) AT=585.025n

* CHECK dout1_6 Vdout1_6ck116 = 0 time = 585
.meas tran vdout1_6ck116 FIND v(dout1_6) AT=585.025n

* CHECK dout1_7 Vdout1_7ck116 = 0 time = 585
.meas tran vdout1_7ck116 FIND v(dout1_7) AT=585.025n

* CHECK dout1_8 Vdout1_8ck116 = 0.9 time = 585
.meas tran vdout1_8ck116 FIND v(dout1_8) AT=585.025n

* CHECK dout1_9 Vdout1_9ck116 = 0.9 time = 585
.meas tran vdout1_9ck116 FIND v(dout1_9) AT=585.025n

* CHECK dout1_10 Vdout1_10ck116 = 0 time = 585
.meas tran vdout1_10ck116 FIND v(dout1_10) AT=585.025n

* CHECK dout1_11 Vdout1_11ck116 = 0 time = 585
.meas tran vdout1_11ck116 FIND v(dout1_11) AT=585.025n

* CHECK dout1_12 Vdout1_12ck116 = 0 time = 585
.meas tran vdout1_12ck116 FIND v(dout1_12) AT=585.025n

* CHECK dout1_13 Vdout1_13ck116 = 0 time = 585
.meas tran vdout1_13ck116 FIND v(dout1_13) AT=585.025n

* CHECK dout1_14 Vdout1_14ck116 = 0.9 time = 585
.meas tran vdout1_14ck116 FIND v(dout1_14) AT=585.025n

* CHECK dout1_15 Vdout1_15ck116 = 0 time = 585
.meas tran vdout1_15ck116 FIND v(dout1_15) AT=585.025n

* CHECK dout1_16 Vdout1_16ck116 = 0.9 time = 585
.meas tran vdout1_16ck116 FIND v(dout1_16) AT=585.025n

* CHECK dout1_17 Vdout1_17ck116 = 0.9 time = 585
.meas tran vdout1_17ck116 FIND v(dout1_17) AT=585.025n

* CHECK dout1_18 Vdout1_18ck116 = 0 time = 585
.meas tran vdout1_18ck116 FIND v(dout1_18) AT=585.025n

* CHECK dout1_19 Vdout1_19ck116 = 0.9 time = 585
.meas tran vdout1_19ck116 FIND v(dout1_19) AT=585.025n

* CHECK dout1_20 Vdout1_20ck116 = 0.9 time = 585
.meas tran vdout1_20ck116 FIND v(dout1_20) AT=585.025n

* CHECK dout1_21 Vdout1_21ck116 = 0 time = 585
.meas tran vdout1_21ck116 FIND v(dout1_21) AT=585.025n

* CHECK dout1_22 Vdout1_22ck116 = 0.9 time = 585
.meas tran vdout1_22ck116 FIND v(dout1_22) AT=585.025n

* CHECK dout1_23 Vdout1_23ck116 = 0.9 time = 585
.meas tran vdout1_23ck116 FIND v(dout1_23) AT=585.025n

* CHECK dout1_24 Vdout1_24ck116 = 0.9 time = 585
.meas tran vdout1_24ck116 FIND v(dout1_24) AT=585.025n

* CHECK dout1_25 Vdout1_25ck116 = 0 time = 585
.meas tran vdout1_25ck116 FIND v(dout1_25) AT=585.025n

* CHECK dout1_26 Vdout1_26ck116 = 0.9 time = 585
.meas tran vdout1_26ck116 FIND v(dout1_26) AT=585.025n

* CHECK dout1_27 Vdout1_27ck116 = 0 time = 585
.meas tran vdout1_27ck116 FIND v(dout1_27) AT=585.025n

* CHECK dout1_28 Vdout1_28ck116 = 0 time = 585
.meas tran vdout1_28ck116 FIND v(dout1_28) AT=585.025n

* CHECK dout1_29 Vdout1_29ck116 = 0 time = 585
.meas tran vdout1_29ck116 FIND v(dout1_29) AT=585.025n

* CHECK dout1_30 Vdout1_30ck116 = 0 time = 585
.meas tran vdout1_30ck116 FIND v(dout1_30) AT=585.025n

* CHECK dout1_31 Vdout1_31ck116 = 0 time = 585
.meas tran vdout1_31ck116 FIND v(dout1_31) AT=585.025n

* CHECK dout1_32 Vdout1_32ck116 = 0.9 time = 585
.meas tran vdout1_32ck116 FIND v(dout1_32) AT=585.025n

* CHECK dout1_33 Vdout1_33ck116 = 0.9 time = 585
.meas tran vdout1_33ck116 FIND v(dout1_33) AT=585.025n

* CHECK dout1_34 Vdout1_34ck116 = 0 time = 585
.meas tran vdout1_34ck116 FIND v(dout1_34) AT=585.025n

* CHECK dout1_35 Vdout1_35ck116 = 0 time = 585
.meas tran vdout1_35ck116 FIND v(dout1_35) AT=585.025n

* CHECK dout1_36 Vdout1_36ck116 = 0 time = 585
.meas tran vdout1_36ck116 FIND v(dout1_36) AT=585.025n

* CHECK dout1_37 Vdout1_37ck116 = 0 time = 585
.meas tran vdout1_37ck116 FIND v(dout1_37) AT=585.025n

* CHECK dout1_38 Vdout1_38ck116 = 0.9 time = 585
.meas tran vdout1_38ck116 FIND v(dout1_38) AT=585.025n

* CHECK dout1_39 Vdout1_39ck116 = 0.9 time = 585
.meas tran vdout1_39ck116 FIND v(dout1_39) AT=585.025n

* CHECK dout1_40 Vdout1_40ck116 = 0.9 time = 585
.meas tran vdout1_40ck116 FIND v(dout1_40) AT=585.025n

* CHECK dout1_41 Vdout1_41ck116 = 0 time = 585
.meas tran vdout1_41ck116 FIND v(dout1_41) AT=585.025n

* CHECK dout1_42 Vdout1_42ck116 = 0 time = 585
.meas tran vdout1_42ck116 FIND v(dout1_42) AT=585.025n

* CHECK dout1_43 Vdout1_43ck116 = 0 time = 585
.meas tran vdout1_43ck116 FIND v(dout1_43) AT=585.025n

* CHECK dout1_44 Vdout1_44ck116 = 0.9 time = 585
.meas tran vdout1_44ck116 FIND v(dout1_44) AT=585.025n

* CHECK dout1_45 Vdout1_45ck116 = 0 time = 585
.meas tran vdout1_45ck116 FIND v(dout1_45) AT=585.025n

* CHECK dout1_46 Vdout1_46ck116 = 0.9 time = 585
.meas tran vdout1_46ck116 FIND v(dout1_46) AT=585.025n

* CHECK dout1_47 Vdout1_47ck116 = 0.9 time = 585
.meas tran vdout1_47ck116 FIND v(dout1_47) AT=585.025n

* CHECK dout1_48 Vdout1_48ck116 = 0 time = 585
.meas tran vdout1_48ck116 FIND v(dout1_48) AT=585.025n

* CHECK dout1_49 Vdout1_49ck116 = 0.9 time = 585
.meas tran vdout1_49ck116 FIND v(dout1_49) AT=585.025n

* CHECK dout1_50 Vdout1_50ck116 = 0.9 time = 585
.meas tran vdout1_50ck116 FIND v(dout1_50) AT=585.025n

* CHECK dout1_51 Vdout1_51ck116 = 0.9 time = 585
.meas tran vdout1_51ck116 FIND v(dout1_51) AT=585.025n

* CHECK dout1_52 Vdout1_52ck116 = 0.9 time = 585
.meas tran vdout1_52ck116 FIND v(dout1_52) AT=585.025n

* CHECK dout1_53 Vdout1_53ck116 = 0.9 time = 585
.meas tran vdout1_53ck116 FIND v(dout1_53) AT=585.025n

* CHECK dout1_54 Vdout1_54ck116 = 0 time = 585
.meas tran vdout1_54ck116 FIND v(dout1_54) AT=585.025n

* CHECK dout1_55 Vdout1_55ck116 = 0 time = 585
.meas tran vdout1_55ck116 FIND v(dout1_55) AT=585.025n

* CHECK dout1_56 Vdout1_56ck116 = 0 time = 585
.meas tran vdout1_56ck116 FIND v(dout1_56) AT=585.025n

* CHECK dout1_57 Vdout1_57ck116 = 0.9 time = 585
.meas tran vdout1_57ck116 FIND v(dout1_57) AT=585.025n

* CHECK dout1_58 Vdout1_58ck116 = 0.9 time = 585
.meas tran vdout1_58ck116 FIND v(dout1_58) AT=585.025n

* CHECK dout1_59 Vdout1_59ck116 = 0.9 time = 585
.meas tran vdout1_59ck116 FIND v(dout1_59) AT=585.025n

* CHECK dout1_60 Vdout1_60ck116 = 0 time = 585
.meas tran vdout1_60ck116 FIND v(dout1_60) AT=585.025n

* CHECK dout1_61 Vdout1_61ck116 = 0.9 time = 585
.meas tran vdout1_61ck116 FIND v(dout1_61) AT=585.025n

* CHECK dout1_62 Vdout1_62ck116 = 0 time = 585
.meas tran vdout1_62ck116 FIND v(dout1_62) AT=585.025n

* CHECK dout1_63 Vdout1_63ck116 = 0 time = 585
.meas tran vdout1_63ck116 FIND v(dout1_63) AT=585.025n

* CHECK dout1_64 Vdout1_64ck116 = 0.9 time = 585
.meas tran vdout1_64ck116 FIND v(dout1_64) AT=585.025n

* CHECK dout1_65 Vdout1_65ck116 = 0 time = 585
.meas tran vdout1_65ck116 FIND v(dout1_65) AT=585.025n

* CHECK dout1_66 Vdout1_66ck116 = 0 time = 585
.meas tran vdout1_66ck116 FIND v(dout1_66) AT=585.025n

* CHECK dout1_67 Vdout1_67ck116 = 0 time = 585
.meas tran vdout1_67ck116 FIND v(dout1_67) AT=585.025n

* CHECK dout1_68 Vdout1_68ck116 = 0.9 time = 585
.meas tran vdout1_68ck116 FIND v(dout1_68) AT=585.025n

* CHECK dout1_69 Vdout1_69ck116 = 0 time = 585
.meas tran vdout1_69ck116 FIND v(dout1_69) AT=585.025n

* CHECK dout1_70 Vdout1_70ck116 = 0.9 time = 585
.meas tran vdout1_70ck116 FIND v(dout1_70) AT=585.025n

* CHECK dout1_71 Vdout1_71ck116 = 0.9 time = 585
.meas tran vdout1_71ck116 FIND v(dout1_71) AT=585.025n

* CHECK dout1_72 Vdout1_72ck116 = 0.9 time = 585
.meas tran vdout1_72ck116 FIND v(dout1_72) AT=585.025n

* CHECK dout1_73 Vdout1_73ck116 = 0.9 time = 585
.meas tran vdout1_73ck116 FIND v(dout1_73) AT=585.025n

* CHECK dout1_74 Vdout1_74ck116 = 0 time = 585
.meas tran vdout1_74ck116 FIND v(dout1_74) AT=585.025n

* CHECK dout1_75 Vdout1_75ck116 = 0.9 time = 585
.meas tran vdout1_75ck116 FIND v(dout1_75) AT=585.025n

* CHECK dout1_76 Vdout1_76ck116 = 0.9 time = 585
.meas tran vdout1_76ck116 FIND v(dout1_76) AT=585.025n

* CHECK dout1_77 Vdout1_77ck116 = 0.9 time = 585
.meas tran vdout1_77ck116 FIND v(dout1_77) AT=585.025n

* CHECK dout1_78 Vdout1_78ck116 = 0.9 time = 585
.meas tran vdout1_78ck116 FIND v(dout1_78) AT=585.025n

* CHECK dout1_79 Vdout1_79ck116 = 0.9 time = 585
.meas tran vdout1_79ck116 FIND v(dout1_79) AT=585.025n

* CHECK dout1_80 Vdout1_80ck116 = 0.9 time = 585
.meas tran vdout1_80ck116 FIND v(dout1_80) AT=585.025n

* CHECK dout1_81 Vdout1_81ck116 = 0.9 time = 585
.meas tran vdout1_81ck116 FIND v(dout1_81) AT=585.025n

* CHECK dout1_82 Vdout1_82ck116 = 0 time = 585
.meas tran vdout1_82ck116 FIND v(dout1_82) AT=585.025n

* CHECK dout1_83 Vdout1_83ck116 = 0 time = 585
.meas tran vdout1_83ck116 FIND v(dout1_83) AT=585.025n

* CHECK dout1_84 Vdout1_84ck116 = 0 time = 585
.meas tran vdout1_84ck116 FIND v(dout1_84) AT=585.025n

* CHECK dout1_85 Vdout1_85ck116 = 0.9 time = 585
.meas tran vdout1_85ck116 FIND v(dout1_85) AT=585.025n

* CHECK dout1_86 Vdout1_86ck116 = 0.9 time = 585
.meas tran vdout1_86ck116 FIND v(dout1_86) AT=585.025n

* CHECK dout1_87 Vdout1_87ck116 = 0 time = 585
.meas tran vdout1_87ck116 FIND v(dout1_87) AT=585.025n

* CHECK dout1_88 Vdout1_88ck116 = 0.9 time = 585
.meas tran vdout1_88ck116 FIND v(dout1_88) AT=585.025n

* CHECK dout1_89 Vdout1_89ck116 = 0.9 time = 585
.meas tran vdout1_89ck116 FIND v(dout1_89) AT=585.025n

* CHECK dout1_90 Vdout1_90ck116 = 0 time = 585
.meas tran vdout1_90ck116 FIND v(dout1_90) AT=585.025n

* CHECK dout1_91 Vdout1_91ck116 = 0 time = 585
.meas tran vdout1_91ck116 FIND v(dout1_91) AT=585.025n

* CHECK dout1_92 Vdout1_92ck116 = 0.9 time = 585
.meas tran vdout1_92ck116 FIND v(dout1_92) AT=585.025n

* CHECK dout1_93 Vdout1_93ck116 = 0 time = 585
.meas tran vdout1_93ck116 FIND v(dout1_93) AT=585.025n

* CHECK dout1_94 Vdout1_94ck116 = 0.9 time = 585
.meas tran vdout1_94ck116 FIND v(dout1_94) AT=585.025n

* CHECK dout1_95 Vdout1_95ck116 = 0 time = 585
.meas tran vdout1_95ck116 FIND v(dout1_95) AT=585.025n

* CHECK dout1_96 Vdout1_96ck116 = 0.9 time = 585
.meas tran vdout1_96ck116 FIND v(dout1_96) AT=585.025n

* CHECK dout1_97 Vdout1_97ck116 = 0.9 time = 585
.meas tran vdout1_97ck116 FIND v(dout1_97) AT=585.025n

* CHECK dout1_98 Vdout1_98ck116 = 0 time = 585
.meas tran vdout1_98ck116 FIND v(dout1_98) AT=585.025n

* CHECK dout1_99 Vdout1_99ck116 = 0 time = 585
.meas tran vdout1_99ck116 FIND v(dout1_99) AT=585.025n

* CHECK dout1_100 Vdout1_100ck116 = 0 time = 585
.meas tran vdout1_100ck116 FIND v(dout1_100) AT=585.025n

* CHECK dout1_101 Vdout1_101ck116 = 0 time = 585
.meas tran vdout1_101ck116 FIND v(dout1_101) AT=585.025n

* CHECK dout1_102 Vdout1_102ck116 = 0.9 time = 585
.meas tran vdout1_102ck116 FIND v(dout1_102) AT=585.025n

* CHECK dout1_103 Vdout1_103ck116 = 0 time = 585
.meas tran vdout1_103ck116 FIND v(dout1_103) AT=585.025n

* CHECK dout1_104 Vdout1_104ck116 = 0.9 time = 585
.meas tran vdout1_104ck116 FIND v(dout1_104) AT=585.025n

* CHECK dout1_105 Vdout1_105ck116 = 0 time = 585
.meas tran vdout1_105ck116 FIND v(dout1_105) AT=585.025n

* CHECK dout1_106 Vdout1_106ck116 = 0 time = 585
.meas tran vdout1_106ck116 FIND v(dout1_106) AT=585.025n

* CHECK dout1_107 Vdout1_107ck116 = 0.9 time = 585
.meas tran vdout1_107ck116 FIND v(dout1_107) AT=585.025n

* CHECK dout1_108 Vdout1_108ck116 = 0.9 time = 585
.meas tran vdout1_108ck116 FIND v(dout1_108) AT=585.025n

* CHECK dout1_109 Vdout1_109ck116 = 0.9 time = 585
.meas tran vdout1_109ck116 FIND v(dout1_109) AT=585.025n

* CHECK dout1_110 Vdout1_110ck116 = 0 time = 585
.meas tran vdout1_110ck116 FIND v(dout1_110) AT=585.025n

* CHECK dout1_111 Vdout1_111ck116 = 0.9 time = 585
.meas tran vdout1_111ck116 FIND v(dout1_111) AT=585.025n

* CHECK dout1_112 Vdout1_112ck116 = 0.9 time = 585
.meas tran vdout1_112ck116 FIND v(dout1_112) AT=585.025n

* CHECK dout1_113 Vdout1_113ck116 = 0.9 time = 585
.meas tran vdout1_113ck116 FIND v(dout1_113) AT=585.025n

* CHECK dout1_114 Vdout1_114ck116 = 0.9 time = 585
.meas tran vdout1_114ck116 FIND v(dout1_114) AT=585.025n

* CHECK dout1_115 Vdout1_115ck116 = 0 time = 585
.meas tran vdout1_115ck116 FIND v(dout1_115) AT=585.025n

* CHECK dout1_116 Vdout1_116ck116 = 0 time = 585
.meas tran vdout1_116ck116 FIND v(dout1_116) AT=585.025n

* CHECK dout1_117 Vdout1_117ck116 = 0.9 time = 585
.meas tran vdout1_117ck116 FIND v(dout1_117) AT=585.025n

* CHECK dout1_118 Vdout1_118ck116 = 0 time = 585
.meas tran vdout1_118ck116 FIND v(dout1_118) AT=585.025n

* CHECK dout1_119 Vdout1_119ck116 = 0.9 time = 585
.meas tran vdout1_119ck116 FIND v(dout1_119) AT=585.025n

* CHECK dout1_0 Vdout1_0ck118 = 0 time = 595
.meas tran vdout1_0ck118 FIND v(dout1_0) AT=595.025n

* CHECK dout1_1 Vdout1_1ck118 = 0.9 time = 595
.meas tran vdout1_1ck118 FIND v(dout1_1) AT=595.025n

* CHECK dout1_2 Vdout1_2ck118 = 0 time = 595
.meas tran vdout1_2ck118 FIND v(dout1_2) AT=595.025n

* CHECK dout1_3 Vdout1_3ck118 = 0 time = 595
.meas tran vdout1_3ck118 FIND v(dout1_3) AT=595.025n

* CHECK dout1_4 Vdout1_4ck118 = 0 time = 595
.meas tran vdout1_4ck118 FIND v(dout1_4) AT=595.025n

* CHECK dout1_5 Vdout1_5ck118 = 0.9 time = 595
.meas tran vdout1_5ck118 FIND v(dout1_5) AT=595.025n

* CHECK dout1_6 Vdout1_6ck118 = 0 time = 595
.meas tran vdout1_6ck118 FIND v(dout1_6) AT=595.025n

* CHECK dout1_7 Vdout1_7ck118 = 0 time = 595
.meas tran vdout1_7ck118 FIND v(dout1_7) AT=595.025n

* CHECK dout1_8 Vdout1_8ck118 = 0.9 time = 595
.meas tran vdout1_8ck118 FIND v(dout1_8) AT=595.025n

* CHECK dout1_9 Vdout1_9ck118 = 0.9 time = 595
.meas tran vdout1_9ck118 FIND v(dout1_9) AT=595.025n

* CHECK dout1_10 Vdout1_10ck118 = 0 time = 595
.meas tran vdout1_10ck118 FIND v(dout1_10) AT=595.025n

* CHECK dout1_11 Vdout1_11ck118 = 0 time = 595
.meas tran vdout1_11ck118 FIND v(dout1_11) AT=595.025n

* CHECK dout1_12 Vdout1_12ck118 = 0 time = 595
.meas tran vdout1_12ck118 FIND v(dout1_12) AT=595.025n

* CHECK dout1_13 Vdout1_13ck118 = 0 time = 595
.meas tran vdout1_13ck118 FIND v(dout1_13) AT=595.025n

* CHECK dout1_14 Vdout1_14ck118 = 0.9 time = 595
.meas tran vdout1_14ck118 FIND v(dout1_14) AT=595.025n

* CHECK dout1_15 Vdout1_15ck118 = 0 time = 595
.meas tran vdout1_15ck118 FIND v(dout1_15) AT=595.025n

* CHECK dout1_16 Vdout1_16ck118 = 0.9 time = 595
.meas tran vdout1_16ck118 FIND v(dout1_16) AT=595.025n

* CHECK dout1_17 Vdout1_17ck118 = 0.9 time = 595
.meas tran vdout1_17ck118 FIND v(dout1_17) AT=595.025n

* CHECK dout1_18 Vdout1_18ck118 = 0 time = 595
.meas tran vdout1_18ck118 FIND v(dout1_18) AT=595.025n

* CHECK dout1_19 Vdout1_19ck118 = 0.9 time = 595
.meas tran vdout1_19ck118 FIND v(dout1_19) AT=595.025n

* CHECK dout1_20 Vdout1_20ck118 = 0.9 time = 595
.meas tran vdout1_20ck118 FIND v(dout1_20) AT=595.025n

* CHECK dout1_21 Vdout1_21ck118 = 0 time = 595
.meas tran vdout1_21ck118 FIND v(dout1_21) AT=595.025n

* CHECK dout1_22 Vdout1_22ck118 = 0.9 time = 595
.meas tran vdout1_22ck118 FIND v(dout1_22) AT=595.025n

* CHECK dout1_23 Vdout1_23ck118 = 0.9 time = 595
.meas tran vdout1_23ck118 FIND v(dout1_23) AT=595.025n

* CHECK dout1_24 Vdout1_24ck118 = 0.9 time = 595
.meas tran vdout1_24ck118 FIND v(dout1_24) AT=595.025n

* CHECK dout1_25 Vdout1_25ck118 = 0 time = 595
.meas tran vdout1_25ck118 FIND v(dout1_25) AT=595.025n

* CHECK dout1_26 Vdout1_26ck118 = 0.9 time = 595
.meas tran vdout1_26ck118 FIND v(dout1_26) AT=595.025n

* CHECK dout1_27 Vdout1_27ck118 = 0 time = 595
.meas tran vdout1_27ck118 FIND v(dout1_27) AT=595.025n

* CHECK dout1_28 Vdout1_28ck118 = 0 time = 595
.meas tran vdout1_28ck118 FIND v(dout1_28) AT=595.025n

* CHECK dout1_29 Vdout1_29ck118 = 0 time = 595
.meas tran vdout1_29ck118 FIND v(dout1_29) AT=595.025n

* CHECK dout1_30 Vdout1_30ck118 = 0 time = 595
.meas tran vdout1_30ck118 FIND v(dout1_30) AT=595.025n

* CHECK dout1_31 Vdout1_31ck118 = 0 time = 595
.meas tran vdout1_31ck118 FIND v(dout1_31) AT=595.025n

* CHECK dout1_32 Vdout1_32ck118 = 0.9 time = 595
.meas tran vdout1_32ck118 FIND v(dout1_32) AT=595.025n

* CHECK dout1_33 Vdout1_33ck118 = 0.9 time = 595
.meas tran vdout1_33ck118 FIND v(dout1_33) AT=595.025n

* CHECK dout1_34 Vdout1_34ck118 = 0 time = 595
.meas tran vdout1_34ck118 FIND v(dout1_34) AT=595.025n

* CHECK dout1_35 Vdout1_35ck118 = 0 time = 595
.meas tran vdout1_35ck118 FIND v(dout1_35) AT=595.025n

* CHECK dout1_36 Vdout1_36ck118 = 0 time = 595
.meas tran vdout1_36ck118 FIND v(dout1_36) AT=595.025n

* CHECK dout1_37 Vdout1_37ck118 = 0 time = 595
.meas tran vdout1_37ck118 FIND v(dout1_37) AT=595.025n

* CHECK dout1_38 Vdout1_38ck118 = 0.9 time = 595
.meas tran vdout1_38ck118 FIND v(dout1_38) AT=595.025n

* CHECK dout1_39 Vdout1_39ck118 = 0.9 time = 595
.meas tran vdout1_39ck118 FIND v(dout1_39) AT=595.025n

* CHECK dout1_40 Vdout1_40ck118 = 0.9 time = 595
.meas tran vdout1_40ck118 FIND v(dout1_40) AT=595.025n

* CHECK dout1_41 Vdout1_41ck118 = 0 time = 595
.meas tran vdout1_41ck118 FIND v(dout1_41) AT=595.025n

* CHECK dout1_42 Vdout1_42ck118 = 0 time = 595
.meas tran vdout1_42ck118 FIND v(dout1_42) AT=595.025n

* CHECK dout1_43 Vdout1_43ck118 = 0 time = 595
.meas tran vdout1_43ck118 FIND v(dout1_43) AT=595.025n

* CHECK dout1_44 Vdout1_44ck118 = 0.9 time = 595
.meas tran vdout1_44ck118 FIND v(dout1_44) AT=595.025n

* CHECK dout1_45 Vdout1_45ck118 = 0 time = 595
.meas tran vdout1_45ck118 FIND v(dout1_45) AT=595.025n

* CHECK dout1_46 Vdout1_46ck118 = 0.9 time = 595
.meas tran vdout1_46ck118 FIND v(dout1_46) AT=595.025n

* CHECK dout1_47 Vdout1_47ck118 = 0.9 time = 595
.meas tran vdout1_47ck118 FIND v(dout1_47) AT=595.025n

* CHECK dout1_48 Vdout1_48ck118 = 0 time = 595
.meas tran vdout1_48ck118 FIND v(dout1_48) AT=595.025n

* CHECK dout1_49 Vdout1_49ck118 = 0.9 time = 595
.meas tran vdout1_49ck118 FIND v(dout1_49) AT=595.025n

* CHECK dout1_50 Vdout1_50ck118 = 0.9 time = 595
.meas tran vdout1_50ck118 FIND v(dout1_50) AT=595.025n

* CHECK dout1_51 Vdout1_51ck118 = 0.9 time = 595
.meas tran vdout1_51ck118 FIND v(dout1_51) AT=595.025n

* CHECK dout1_52 Vdout1_52ck118 = 0.9 time = 595
.meas tran vdout1_52ck118 FIND v(dout1_52) AT=595.025n

* CHECK dout1_53 Vdout1_53ck118 = 0.9 time = 595
.meas tran vdout1_53ck118 FIND v(dout1_53) AT=595.025n

* CHECK dout1_54 Vdout1_54ck118 = 0 time = 595
.meas tran vdout1_54ck118 FIND v(dout1_54) AT=595.025n

* CHECK dout1_55 Vdout1_55ck118 = 0 time = 595
.meas tran vdout1_55ck118 FIND v(dout1_55) AT=595.025n

* CHECK dout1_56 Vdout1_56ck118 = 0 time = 595
.meas tran vdout1_56ck118 FIND v(dout1_56) AT=595.025n

* CHECK dout1_57 Vdout1_57ck118 = 0.9 time = 595
.meas tran vdout1_57ck118 FIND v(dout1_57) AT=595.025n

* CHECK dout1_58 Vdout1_58ck118 = 0.9 time = 595
.meas tran vdout1_58ck118 FIND v(dout1_58) AT=595.025n

* CHECK dout1_59 Vdout1_59ck118 = 0.9 time = 595
.meas tran vdout1_59ck118 FIND v(dout1_59) AT=595.025n

* CHECK dout1_60 Vdout1_60ck118 = 0 time = 595
.meas tran vdout1_60ck118 FIND v(dout1_60) AT=595.025n

* CHECK dout1_61 Vdout1_61ck118 = 0.9 time = 595
.meas tran vdout1_61ck118 FIND v(dout1_61) AT=595.025n

* CHECK dout1_62 Vdout1_62ck118 = 0 time = 595
.meas tran vdout1_62ck118 FIND v(dout1_62) AT=595.025n

* CHECK dout1_63 Vdout1_63ck118 = 0 time = 595
.meas tran vdout1_63ck118 FIND v(dout1_63) AT=595.025n

* CHECK dout1_64 Vdout1_64ck118 = 0.9 time = 595
.meas tran vdout1_64ck118 FIND v(dout1_64) AT=595.025n

* CHECK dout1_65 Vdout1_65ck118 = 0 time = 595
.meas tran vdout1_65ck118 FIND v(dout1_65) AT=595.025n

* CHECK dout1_66 Vdout1_66ck118 = 0 time = 595
.meas tran vdout1_66ck118 FIND v(dout1_66) AT=595.025n

* CHECK dout1_67 Vdout1_67ck118 = 0 time = 595
.meas tran vdout1_67ck118 FIND v(dout1_67) AT=595.025n

* CHECK dout1_68 Vdout1_68ck118 = 0.9 time = 595
.meas tran vdout1_68ck118 FIND v(dout1_68) AT=595.025n

* CHECK dout1_69 Vdout1_69ck118 = 0 time = 595
.meas tran vdout1_69ck118 FIND v(dout1_69) AT=595.025n

* CHECK dout1_70 Vdout1_70ck118 = 0.9 time = 595
.meas tran vdout1_70ck118 FIND v(dout1_70) AT=595.025n

* CHECK dout1_71 Vdout1_71ck118 = 0.9 time = 595
.meas tran vdout1_71ck118 FIND v(dout1_71) AT=595.025n

* CHECK dout1_72 Vdout1_72ck118 = 0.9 time = 595
.meas tran vdout1_72ck118 FIND v(dout1_72) AT=595.025n

* CHECK dout1_73 Vdout1_73ck118 = 0.9 time = 595
.meas tran vdout1_73ck118 FIND v(dout1_73) AT=595.025n

* CHECK dout1_74 Vdout1_74ck118 = 0 time = 595
.meas tran vdout1_74ck118 FIND v(dout1_74) AT=595.025n

* CHECK dout1_75 Vdout1_75ck118 = 0.9 time = 595
.meas tran vdout1_75ck118 FIND v(dout1_75) AT=595.025n

* CHECK dout1_76 Vdout1_76ck118 = 0.9 time = 595
.meas tran vdout1_76ck118 FIND v(dout1_76) AT=595.025n

* CHECK dout1_77 Vdout1_77ck118 = 0.9 time = 595
.meas tran vdout1_77ck118 FIND v(dout1_77) AT=595.025n

* CHECK dout1_78 Vdout1_78ck118 = 0.9 time = 595
.meas tran vdout1_78ck118 FIND v(dout1_78) AT=595.025n

* CHECK dout1_79 Vdout1_79ck118 = 0.9 time = 595
.meas tran vdout1_79ck118 FIND v(dout1_79) AT=595.025n

* CHECK dout1_80 Vdout1_80ck118 = 0.9 time = 595
.meas tran vdout1_80ck118 FIND v(dout1_80) AT=595.025n

* CHECK dout1_81 Vdout1_81ck118 = 0.9 time = 595
.meas tran vdout1_81ck118 FIND v(dout1_81) AT=595.025n

* CHECK dout1_82 Vdout1_82ck118 = 0 time = 595
.meas tran vdout1_82ck118 FIND v(dout1_82) AT=595.025n

* CHECK dout1_83 Vdout1_83ck118 = 0 time = 595
.meas tran vdout1_83ck118 FIND v(dout1_83) AT=595.025n

* CHECK dout1_84 Vdout1_84ck118 = 0 time = 595
.meas tran vdout1_84ck118 FIND v(dout1_84) AT=595.025n

* CHECK dout1_85 Vdout1_85ck118 = 0.9 time = 595
.meas tran vdout1_85ck118 FIND v(dout1_85) AT=595.025n

* CHECK dout1_86 Vdout1_86ck118 = 0.9 time = 595
.meas tran vdout1_86ck118 FIND v(dout1_86) AT=595.025n

* CHECK dout1_87 Vdout1_87ck118 = 0 time = 595
.meas tran vdout1_87ck118 FIND v(dout1_87) AT=595.025n

* CHECK dout1_88 Vdout1_88ck118 = 0.9 time = 595
.meas tran vdout1_88ck118 FIND v(dout1_88) AT=595.025n

* CHECK dout1_89 Vdout1_89ck118 = 0.9 time = 595
.meas tran vdout1_89ck118 FIND v(dout1_89) AT=595.025n

* CHECK dout1_90 Vdout1_90ck118 = 0 time = 595
.meas tran vdout1_90ck118 FIND v(dout1_90) AT=595.025n

* CHECK dout1_91 Vdout1_91ck118 = 0 time = 595
.meas tran vdout1_91ck118 FIND v(dout1_91) AT=595.025n

* CHECK dout1_92 Vdout1_92ck118 = 0.9 time = 595
.meas tran vdout1_92ck118 FIND v(dout1_92) AT=595.025n

* CHECK dout1_93 Vdout1_93ck118 = 0 time = 595
.meas tran vdout1_93ck118 FIND v(dout1_93) AT=595.025n

* CHECK dout1_94 Vdout1_94ck118 = 0.9 time = 595
.meas tran vdout1_94ck118 FIND v(dout1_94) AT=595.025n

* CHECK dout1_95 Vdout1_95ck118 = 0 time = 595
.meas tran vdout1_95ck118 FIND v(dout1_95) AT=595.025n

* CHECK dout1_96 Vdout1_96ck118 = 0.9 time = 595
.meas tran vdout1_96ck118 FIND v(dout1_96) AT=595.025n

* CHECK dout1_97 Vdout1_97ck118 = 0.9 time = 595
.meas tran vdout1_97ck118 FIND v(dout1_97) AT=595.025n

* CHECK dout1_98 Vdout1_98ck118 = 0 time = 595
.meas tran vdout1_98ck118 FIND v(dout1_98) AT=595.025n

* CHECK dout1_99 Vdout1_99ck118 = 0 time = 595
.meas tran vdout1_99ck118 FIND v(dout1_99) AT=595.025n

* CHECK dout1_100 Vdout1_100ck118 = 0 time = 595
.meas tran vdout1_100ck118 FIND v(dout1_100) AT=595.025n

* CHECK dout1_101 Vdout1_101ck118 = 0 time = 595
.meas tran vdout1_101ck118 FIND v(dout1_101) AT=595.025n

* CHECK dout1_102 Vdout1_102ck118 = 0.9 time = 595
.meas tran vdout1_102ck118 FIND v(dout1_102) AT=595.025n

* CHECK dout1_103 Vdout1_103ck118 = 0 time = 595
.meas tran vdout1_103ck118 FIND v(dout1_103) AT=595.025n

* CHECK dout1_104 Vdout1_104ck118 = 0.9 time = 595
.meas tran vdout1_104ck118 FIND v(dout1_104) AT=595.025n

* CHECK dout1_105 Vdout1_105ck118 = 0 time = 595
.meas tran vdout1_105ck118 FIND v(dout1_105) AT=595.025n

* CHECK dout1_106 Vdout1_106ck118 = 0 time = 595
.meas tran vdout1_106ck118 FIND v(dout1_106) AT=595.025n

* CHECK dout1_107 Vdout1_107ck118 = 0.9 time = 595
.meas tran vdout1_107ck118 FIND v(dout1_107) AT=595.025n

* CHECK dout1_108 Vdout1_108ck118 = 0.9 time = 595
.meas tran vdout1_108ck118 FIND v(dout1_108) AT=595.025n

* CHECK dout1_109 Vdout1_109ck118 = 0.9 time = 595
.meas tran vdout1_109ck118 FIND v(dout1_109) AT=595.025n

* CHECK dout1_110 Vdout1_110ck118 = 0 time = 595
.meas tran vdout1_110ck118 FIND v(dout1_110) AT=595.025n

* CHECK dout1_111 Vdout1_111ck118 = 0.9 time = 595
.meas tran vdout1_111ck118 FIND v(dout1_111) AT=595.025n

* CHECK dout1_112 Vdout1_112ck118 = 0.9 time = 595
.meas tran vdout1_112ck118 FIND v(dout1_112) AT=595.025n

* CHECK dout1_113 Vdout1_113ck118 = 0.9 time = 595
.meas tran vdout1_113ck118 FIND v(dout1_113) AT=595.025n

* CHECK dout1_114 Vdout1_114ck118 = 0.9 time = 595
.meas tran vdout1_114ck118 FIND v(dout1_114) AT=595.025n

* CHECK dout1_115 Vdout1_115ck118 = 0 time = 595
.meas tran vdout1_115ck118 FIND v(dout1_115) AT=595.025n

* CHECK dout1_116 Vdout1_116ck118 = 0 time = 595
.meas tran vdout1_116ck118 FIND v(dout1_116) AT=595.025n

* CHECK dout1_117 Vdout1_117ck118 = 0.9 time = 595
.meas tran vdout1_117ck118 FIND v(dout1_117) AT=595.025n

* CHECK dout1_118 Vdout1_118ck118 = 0 time = 595
.meas tran vdout1_118ck118 FIND v(dout1_118) AT=595.025n

* CHECK dout1_119 Vdout1_119ck118 = 0.9 time = 595
.meas tran vdout1_119ck118 FIND v(dout1_119) AT=595.025n

* CHECK dout1_0 Vdout1_0ck119 = 0.9 time = 600
.meas tran vdout1_0ck119 FIND v(dout1_0) AT=600.025n

* CHECK dout1_1 Vdout1_1ck119 = 0 time = 600
.meas tran vdout1_1ck119 FIND v(dout1_1) AT=600.025n

* CHECK dout1_2 Vdout1_2ck119 = 0 time = 600
.meas tran vdout1_2ck119 FIND v(dout1_2) AT=600.025n

* CHECK dout1_3 Vdout1_3ck119 = 0 time = 600
.meas tran vdout1_3ck119 FIND v(dout1_3) AT=600.025n

* CHECK dout1_4 Vdout1_4ck119 = 0.9 time = 600
.meas tran vdout1_4ck119 FIND v(dout1_4) AT=600.025n

* CHECK dout1_5 Vdout1_5ck119 = 0 time = 600
.meas tran vdout1_5ck119 FIND v(dout1_5) AT=600.025n

* CHECK dout1_6 Vdout1_6ck119 = 0 time = 600
.meas tran vdout1_6ck119 FIND v(dout1_6) AT=600.025n

* CHECK dout1_7 Vdout1_7ck119 = 0.9 time = 600
.meas tran vdout1_7ck119 FIND v(dout1_7) AT=600.025n

* CHECK dout1_8 Vdout1_8ck119 = 0 time = 600
.meas tran vdout1_8ck119 FIND v(dout1_8) AT=600.025n

* CHECK dout1_9 Vdout1_9ck119 = 0.9 time = 600
.meas tran vdout1_9ck119 FIND v(dout1_9) AT=600.025n

* CHECK dout1_10 Vdout1_10ck119 = 0 time = 600
.meas tran vdout1_10ck119 FIND v(dout1_10) AT=600.025n

* CHECK dout1_11 Vdout1_11ck119 = 0.9 time = 600
.meas tran vdout1_11ck119 FIND v(dout1_11) AT=600.025n

* CHECK dout1_12 Vdout1_12ck119 = 0.9 time = 600
.meas tran vdout1_12ck119 FIND v(dout1_12) AT=600.025n

* CHECK dout1_13 Vdout1_13ck119 = 0 time = 600
.meas tran vdout1_13ck119 FIND v(dout1_13) AT=600.025n

* CHECK dout1_14 Vdout1_14ck119 = 0.9 time = 600
.meas tran vdout1_14ck119 FIND v(dout1_14) AT=600.025n

* CHECK dout1_15 Vdout1_15ck119 = 0 time = 600
.meas tran vdout1_15ck119 FIND v(dout1_15) AT=600.025n

* CHECK dout1_16 Vdout1_16ck119 = 0.9 time = 600
.meas tran vdout1_16ck119 FIND v(dout1_16) AT=600.025n

* CHECK dout1_17 Vdout1_17ck119 = 0.9 time = 600
.meas tran vdout1_17ck119 FIND v(dout1_17) AT=600.025n

* CHECK dout1_18 Vdout1_18ck119 = 0 time = 600
.meas tran vdout1_18ck119 FIND v(dout1_18) AT=600.025n

* CHECK dout1_19 Vdout1_19ck119 = 0.9 time = 600
.meas tran vdout1_19ck119 FIND v(dout1_19) AT=600.025n

* CHECK dout1_20 Vdout1_20ck119 = 0.9 time = 600
.meas tran vdout1_20ck119 FIND v(dout1_20) AT=600.025n

* CHECK dout1_21 Vdout1_21ck119 = 0 time = 600
.meas tran vdout1_21ck119 FIND v(dout1_21) AT=600.025n

* CHECK dout1_22 Vdout1_22ck119 = 0.9 time = 600
.meas tran vdout1_22ck119 FIND v(dout1_22) AT=600.025n

* CHECK dout1_23 Vdout1_23ck119 = 0.9 time = 600
.meas tran vdout1_23ck119 FIND v(dout1_23) AT=600.025n

* CHECK dout1_24 Vdout1_24ck119 = 0.9 time = 600
.meas tran vdout1_24ck119 FIND v(dout1_24) AT=600.025n

* CHECK dout1_25 Vdout1_25ck119 = 0.9 time = 600
.meas tran vdout1_25ck119 FIND v(dout1_25) AT=600.025n

* CHECK dout1_26 Vdout1_26ck119 = 0 time = 600
.meas tran vdout1_26ck119 FIND v(dout1_26) AT=600.025n

* CHECK dout1_27 Vdout1_27ck119 = 0.9 time = 600
.meas tran vdout1_27ck119 FIND v(dout1_27) AT=600.025n

* CHECK dout1_28 Vdout1_28ck119 = 0 time = 600
.meas tran vdout1_28ck119 FIND v(dout1_28) AT=600.025n

* CHECK dout1_29 Vdout1_29ck119 = 0 time = 600
.meas tran vdout1_29ck119 FIND v(dout1_29) AT=600.025n

* CHECK dout1_30 Vdout1_30ck119 = 0 time = 600
.meas tran vdout1_30ck119 FIND v(dout1_30) AT=600.025n

* CHECK dout1_31 Vdout1_31ck119 = 0.9 time = 600
.meas tran vdout1_31ck119 FIND v(dout1_31) AT=600.025n

* CHECK dout1_32 Vdout1_32ck119 = 0.9 time = 600
.meas tran vdout1_32ck119 FIND v(dout1_32) AT=600.025n

* CHECK dout1_33 Vdout1_33ck119 = 0 time = 600
.meas tran vdout1_33ck119 FIND v(dout1_33) AT=600.025n

* CHECK dout1_34 Vdout1_34ck119 = 0.9 time = 600
.meas tran vdout1_34ck119 FIND v(dout1_34) AT=600.025n

* CHECK dout1_35 Vdout1_35ck119 = 0.9 time = 600
.meas tran vdout1_35ck119 FIND v(dout1_35) AT=600.025n

* CHECK dout1_36 Vdout1_36ck119 = 0.9 time = 600
.meas tran vdout1_36ck119 FIND v(dout1_36) AT=600.025n

* CHECK dout1_37 Vdout1_37ck119 = 0.9 time = 600
.meas tran vdout1_37ck119 FIND v(dout1_37) AT=600.025n

* CHECK dout1_38 Vdout1_38ck119 = 0 time = 600
.meas tran vdout1_38ck119 FIND v(dout1_38) AT=600.025n

* CHECK dout1_39 Vdout1_39ck119 = 0 time = 600
.meas tran vdout1_39ck119 FIND v(dout1_39) AT=600.025n

* CHECK dout1_40 Vdout1_40ck119 = 0 time = 600
.meas tran vdout1_40ck119 FIND v(dout1_40) AT=600.025n

* CHECK dout1_41 Vdout1_41ck119 = 0.9 time = 600
.meas tran vdout1_41ck119 FIND v(dout1_41) AT=600.025n

* CHECK dout1_42 Vdout1_42ck119 = 0 time = 600
.meas tran vdout1_42ck119 FIND v(dout1_42) AT=600.025n

* CHECK dout1_43 Vdout1_43ck119 = 0 time = 600
.meas tran vdout1_43ck119 FIND v(dout1_43) AT=600.025n

* CHECK dout1_44 Vdout1_44ck119 = 0.9 time = 600
.meas tran vdout1_44ck119 FIND v(dout1_44) AT=600.025n

* CHECK dout1_45 Vdout1_45ck119 = 0.9 time = 600
.meas tran vdout1_45ck119 FIND v(dout1_45) AT=600.025n

* CHECK dout1_46 Vdout1_46ck119 = 0.9 time = 600
.meas tran vdout1_46ck119 FIND v(dout1_46) AT=600.025n

* CHECK dout1_47 Vdout1_47ck119 = 0.9 time = 600
.meas tran vdout1_47ck119 FIND v(dout1_47) AT=600.025n

* CHECK dout1_48 Vdout1_48ck119 = 0.9 time = 600
.meas tran vdout1_48ck119 FIND v(dout1_48) AT=600.025n

* CHECK dout1_49 Vdout1_49ck119 = 0.9 time = 600
.meas tran vdout1_49ck119 FIND v(dout1_49) AT=600.025n

* CHECK dout1_50 Vdout1_50ck119 = 0 time = 600
.meas tran vdout1_50ck119 FIND v(dout1_50) AT=600.025n

* CHECK dout1_51 Vdout1_51ck119 = 0.9 time = 600
.meas tran vdout1_51ck119 FIND v(dout1_51) AT=600.025n

* CHECK dout1_52 Vdout1_52ck119 = 0 time = 600
.meas tran vdout1_52ck119 FIND v(dout1_52) AT=600.025n

* CHECK dout1_53 Vdout1_53ck119 = 0 time = 600
.meas tran vdout1_53ck119 FIND v(dout1_53) AT=600.025n

* CHECK dout1_54 Vdout1_54ck119 = 0 time = 600
.meas tran vdout1_54ck119 FIND v(dout1_54) AT=600.025n

* CHECK dout1_55 Vdout1_55ck119 = 0 time = 600
.meas tran vdout1_55ck119 FIND v(dout1_55) AT=600.025n

* CHECK dout1_56 Vdout1_56ck119 = 0 time = 600
.meas tran vdout1_56ck119 FIND v(dout1_56) AT=600.025n

* CHECK dout1_57 Vdout1_57ck119 = 0.9 time = 600
.meas tran vdout1_57ck119 FIND v(dout1_57) AT=600.025n

* CHECK dout1_58 Vdout1_58ck119 = 0 time = 600
.meas tran vdout1_58ck119 FIND v(dout1_58) AT=600.025n

* CHECK dout1_59 Vdout1_59ck119 = 0 time = 600
.meas tran vdout1_59ck119 FIND v(dout1_59) AT=600.025n

* CHECK dout1_60 Vdout1_60ck119 = 0.9 time = 600
.meas tran vdout1_60ck119 FIND v(dout1_60) AT=600.025n

* CHECK dout1_61 Vdout1_61ck119 = 0.9 time = 600
.meas tran vdout1_61ck119 FIND v(dout1_61) AT=600.025n

* CHECK dout1_62 Vdout1_62ck119 = 0.9 time = 600
.meas tran vdout1_62ck119 FIND v(dout1_62) AT=600.025n

* CHECK dout1_63 Vdout1_63ck119 = 0.9 time = 600
.meas tran vdout1_63ck119 FIND v(dout1_63) AT=600.025n

* CHECK dout1_64 Vdout1_64ck119 = 0.9 time = 600
.meas tran vdout1_64ck119 FIND v(dout1_64) AT=600.025n

* CHECK dout1_65 Vdout1_65ck119 = 0 time = 600
.meas tran vdout1_65ck119 FIND v(dout1_65) AT=600.025n

* CHECK dout1_66 Vdout1_66ck119 = 0.9 time = 600
.meas tran vdout1_66ck119 FIND v(dout1_66) AT=600.025n

* CHECK dout1_67 Vdout1_67ck119 = 0.9 time = 600
.meas tran vdout1_67ck119 FIND v(dout1_67) AT=600.025n

* CHECK dout1_68 Vdout1_68ck119 = 0 time = 600
.meas tran vdout1_68ck119 FIND v(dout1_68) AT=600.025n

* CHECK dout1_69 Vdout1_69ck119 = 0.9 time = 600
.meas tran vdout1_69ck119 FIND v(dout1_69) AT=600.025n

* CHECK dout1_70 Vdout1_70ck119 = 0 time = 600
.meas tran vdout1_70ck119 FIND v(dout1_70) AT=600.025n

* CHECK dout1_71 Vdout1_71ck119 = 0.9 time = 600
.meas tran vdout1_71ck119 FIND v(dout1_71) AT=600.025n

* CHECK dout1_72 Vdout1_72ck119 = 0 time = 600
.meas tran vdout1_72ck119 FIND v(dout1_72) AT=600.025n

* CHECK dout1_73 Vdout1_73ck119 = 0.9 time = 600
.meas tran vdout1_73ck119 FIND v(dout1_73) AT=600.025n

* CHECK dout1_74 Vdout1_74ck119 = 0 time = 600
.meas tran vdout1_74ck119 FIND v(dout1_74) AT=600.025n

* CHECK dout1_75 Vdout1_75ck119 = 0.9 time = 600
.meas tran vdout1_75ck119 FIND v(dout1_75) AT=600.025n

* CHECK dout1_76 Vdout1_76ck119 = 0.9 time = 600
.meas tran vdout1_76ck119 FIND v(dout1_76) AT=600.025n

* CHECK dout1_77 Vdout1_77ck119 = 0 time = 600
.meas tran vdout1_77ck119 FIND v(dout1_77) AT=600.025n

* CHECK dout1_78 Vdout1_78ck119 = 0 time = 600
.meas tran vdout1_78ck119 FIND v(dout1_78) AT=600.025n

* CHECK dout1_79 Vdout1_79ck119 = 0.9 time = 600
.meas tran vdout1_79ck119 FIND v(dout1_79) AT=600.025n

* CHECK dout1_80 Vdout1_80ck119 = 0.9 time = 600
.meas tran vdout1_80ck119 FIND v(dout1_80) AT=600.025n

* CHECK dout1_81 Vdout1_81ck119 = 0.9 time = 600
.meas tran vdout1_81ck119 FIND v(dout1_81) AT=600.025n

* CHECK dout1_82 Vdout1_82ck119 = 0.9 time = 600
.meas tran vdout1_82ck119 FIND v(dout1_82) AT=600.025n

* CHECK dout1_83 Vdout1_83ck119 = 0 time = 600
.meas tran vdout1_83ck119 FIND v(dout1_83) AT=600.025n

* CHECK dout1_84 Vdout1_84ck119 = 0.9 time = 600
.meas tran vdout1_84ck119 FIND v(dout1_84) AT=600.025n

* CHECK dout1_85 Vdout1_85ck119 = 0.9 time = 600
.meas tran vdout1_85ck119 FIND v(dout1_85) AT=600.025n

* CHECK dout1_86 Vdout1_86ck119 = 0.9 time = 600
.meas tran vdout1_86ck119 FIND v(dout1_86) AT=600.025n

* CHECK dout1_87 Vdout1_87ck119 = 0.9 time = 600
.meas tran vdout1_87ck119 FIND v(dout1_87) AT=600.025n

* CHECK dout1_88 Vdout1_88ck119 = 0 time = 600
.meas tran vdout1_88ck119 FIND v(dout1_88) AT=600.025n

* CHECK dout1_89 Vdout1_89ck119 = 0 time = 600
.meas tran vdout1_89ck119 FIND v(dout1_89) AT=600.025n

* CHECK dout1_90 Vdout1_90ck119 = 0 time = 600
.meas tran vdout1_90ck119 FIND v(dout1_90) AT=600.025n

* CHECK dout1_91 Vdout1_91ck119 = 0 time = 600
.meas tran vdout1_91ck119 FIND v(dout1_91) AT=600.025n

* CHECK dout1_92 Vdout1_92ck119 = 0.9 time = 600
.meas tran vdout1_92ck119 FIND v(dout1_92) AT=600.025n

* CHECK dout1_93 Vdout1_93ck119 = 0 time = 600
.meas tran vdout1_93ck119 FIND v(dout1_93) AT=600.025n

* CHECK dout1_94 Vdout1_94ck119 = 0.9 time = 600
.meas tran vdout1_94ck119 FIND v(dout1_94) AT=600.025n

* CHECK dout1_95 Vdout1_95ck119 = 0 time = 600
.meas tran vdout1_95ck119 FIND v(dout1_95) AT=600.025n

* CHECK dout1_96 Vdout1_96ck119 = 0.9 time = 600
.meas tran vdout1_96ck119 FIND v(dout1_96) AT=600.025n

* CHECK dout1_97 Vdout1_97ck119 = 0 time = 600
.meas tran vdout1_97ck119 FIND v(dout1_97) AT=600.025n

* CHECK dout1_98 Vdout1_98ck119 = 0 time = 600
.meas tran vdout1_98ck119 FIND v(dout1_98) AT=600.025n

* CHECK dout1_99 Vdout1_99ck119 = 0.9 time = 600
.meas tran vdout1_99ck119 FIND v(dout1_99) AT=600.025n

* CHECK dout1_100 Vdout1_100ck119 = 0.9 time = 600
.meas tran vdout1_100ck119 FIND v(dout1_100) AT=600.025n

* CHECK dout1_101 Vdout1_101ck119 = 0.9 time = 600
.meas tran vdout1_101ck119 FIND v(dout1_101) AT=600.025n

* CHECK dout1_102 Vdout1_102ck119 = 0 time = 600
.meas tran vdout1_102ck119 FIND v(dout1_102) AT=600.025n

* CHECK dout1_103 Vdout1_103ck119 = 0.9 time = 600
.meas tran vdout1_103ck119 FIND v(dout1_103) AT=600.025n

* CHECK dout1_104 Vdout1_104ck119 = 0 time = 600
.meas tran vdout1_104ck119 FIND v(dout1_104) AT=600.025n

* CHECK dout1_105 Vdout1_105ck119 = 0.9 time = 600
.meas tran vdout1_105ck119 FIND v(dout1_105) AT=600.025n

* CHECK dout1_106 Vdout1_106ck119 = 0 time = 600
.meas tran vdout1_106ck119 FIND v(dout1_106) AT=600.025n

* CHECK dout1_107 Vdout1_107ck119 = 0 time = 600
.meas tran vdout1_107ck119 FIND v(dout1_107) AT=600.025n

* CHECK dout1_108 Vdout1_108ck119 = 0 time = 600
.meas tran vdout1_108ck119 FIND v(dout1_108) AT=600.025n

* CHECK dout1_109 Vdout1_109ck119 = 0 time = 600
.meas tran vdout1_109ck119 FIND v(dout1_109) AT=600.025n

* CHECK dout1_110 Vdout1_110ck119 = 0 time = 600
.meas tran vdout1_110ck119 FIND v(dout1_110) AT=600.025n

* CHECK dout1_111 Vdout1_111ck119 = 0.9 time = 600
.meas tran vdout1_111ck119 FIND v(dout1_111) AT=600.025n

* CHECK dout1_112 Vdout1_112ck119 = 0.9 time = 600
.meas tran vdout1_112ck119 FIND v(dout1_112) AT=600.025n

* CHECK dout1_113 Vdout1_113ck119 = 0.9 time = 600
.meas tran vdout1_113ck119 FIND v(dout1_113) AT=600.025n

* CHECK dout1_114 Vdout1_114ck119 = 0.9 time = 600
.meas tran vdout1_114ck119 FIND v(dout1_114) AT=600.025n

* CHECK dout1_115 Vdout1_115ck119 = 0.9 time = 600
.meas tran vdout1_115ck119 FIND v(dout1_115) AT=600.025n

* CHECK dout1_116 Vdout1_116ck119 = 0 time = 600
.meas tran vdout1_116ck119 FIND v(dout1_116) AT=600.025n

* CHECK dout1_117 Vdout1_117ck119 = 0.9 time = 600
.meas tran vdout1_117ck119 FIND v(dout1_117) AT=600.025n

* CHECK dout1_118 Vdout1_118ck119 = 0 time = 600
.meas tran vdout1_118ck119 FIND v(dout1_118) AT=600.025n

* CHECK dout1_119 Vdout1_119ck119 = 0.9 time = 600
.meas tran vdout1_119ck119 FIND v(dout1_119) AT=600.025n

* CHECK dout1_0 Vdout1_0ck130 = 0 time = 655
.meas tran vdout1_0ck130 FIND v(dout1_0) AT=655.025n

* CHECK dout1_1 Vdout1_1ck130 = 0 time = 655
.meas tran vdout1_1ck130 FIND v(dout1_1) AT=655.025n

* CHECK dout1_2 Vdout1_2ck130 = 0.9 time = 655
.meas tran vdout1_2ck130 FIND v(dout1_2) AT=655.025n

* CHECK dout1_3 Vdout1_3ck130 = 0.9 time = 655
.meas tran vdout1_3ck130 FIND v(dout1_3) AT=655.025n

* CHECK dout1_4 Vdout1_4ck130 = 0.9 time = 655
.meas tran vdout1_4ck130 FIND v(dout1_4) AT=655.025n

* CHECK dout1_5 Vdout1_5ck130 = 0 time = 655
.meas tran vdout1_5ck130 FIND v(dout1_5) AT=655.025n

* CHECK dout1_6 Vdout1_6ck130 = 0.9 time = 655
.meas tran vdout1_6ck130 FIND v(dout1_6) AT=655.025n

* CHECK dout1_7 Vdout1_7ck130 = 0 time = 655
.meas tran vdout1_7ck130 FIND v(dout1_7) AT=655.025n

* CHECK dout1_8 Vdout1_8ck130 = 0.9 time = 655
.meas tran vdout1_8ck130 FIND v(dout1_8) AT=655.025n

* CHECK dout1_9 Vdout1_9ck130 = 0.9 time = 655
.meas tran vdout1_9ck130 FIND v(dout1_9) AT=655.025n

* CHECK dout1_10 Vdout1_10ck130 = 0 time = 655
.meas tran vdout1_10ck130 FIND v(dout1_10) AT=655.025n

* CHECK dout1_11 Vdout1_11ck130 = 0 time = 655
.meas tran vdout1_11ck130 FIND v(dout1_11) AT=655.025n

* CHECK dout1_12 Vdout1_12ck130 = 0.9 time = 655
.meas tran vdout1_12ck130 FIND v(dout1_12) AT=655.025n

* CHECK dout1_13 Vdout1_13ck130 = 0 time = 655
.meas tran vdout1_13ck130 FIND v(dout1_13) AT=655.025n

* CHECK dout1_14 Vdout1_14ck130 = 0 time = 655
.meas tran vdout1_14ck130 FIND v(dout1_14) AT=655.025n

* CHECK dout1_15 Vdout1_15ck130 = 0 time = 655
.meas tran vdout1_15ck130 FIND v(dout1_15) AT=655.025n

* CHECK dout1_16 Vdout1_16ck130 = 0 time = 655
.meas tran vdout1_16ck130 FIND v(dout1_16) AT=655.025n

* CHECK dout1_17 Vdout1_17ck130 = 0.9 time = 655
.meas tran vdout1_17ck130 FIND v(dout1_17) AT=655.025n

* CHECK dout1_18 Vdout1_18ck130 = 0 time = 655
.meas tran vdout1_18ck130 FIND v(dout1_18) AT=655.025n

* CHECK dout1_19 Vdout1_19ck130 = 0.9 time = 655
.meas tran vdout1_19ck130 FIND v(dout1_19) AT=655.025n

* CHECK dout1_20 Vdout1_20ck130 = 0.9 time = 655
.meas tran vdout1_20ck130 FIND v(dout1_20) AT=655.025n

* CHECK dout1_21 Vdout1_21ck130 = 0 time = 655
.meas tran vdout1_21ck130 FIND v(dout1_21) AT=655.025n

* CHECK dout1_22 Vdout1_22ck130 = 0 time = 655
.meas tran vdout1_22ck130 FIND v(dout1_22) AT=655.025n

* CHECK dout1_23 Vdout1_23ck130 = 0.9 time = 655
.meas tran vdout1_23ck130 FIND v(dout1_23) AT=655.025n

* CHECK dout1_24 Vdout1_24ck130 = 0 time = 655
.meas tran vdout1_24ck130 FIND v(dout1_24) AT=655.025n

* CHECK dout1_25 Vdout1_25ck130 = 0 time = 655
.meas tran vdout1_25ck130 FIND v(dout1_25) AT=655.025n

* CHECK dout1_26 Vdout1_26ck130 = 0 time = 655
.meas tran vdout1_26ck130 FIND v(dout1_26) AT=655.025n

* CHECK dout1_27 Vdout1_27ck130 = 0.9 time = 655
.meas tran vdout1_27ck130 FIND v(dout1_27) AT=655.025n

* CHECK dout1_28 Vdout1_28ck130 = 0.9 time = 655
.meas tran vdout1_28ck130 FIND v(dout1_28) AT=655.025n

* CHECK dout1_29 Vdout1_29ck130 = 0.9 time = 655
.meas tran vdout1_29ck130 FIND v(dout1_29) AT=655.025n

* CHECK dout1_30 Vdout1_30ck130 = 0 time = 655
.meas tran vdout1_30ck130 FIND v(dout1_30) AT=655.025n

* CHECK dout1_31 Vdout1_31ck130 = 0.9 time = 655
.meas tran vdout1_31ck130 FIND v(dout1_31) AT=655.025n

* CHECK dout1_32 Vdout1_32ck130 = 0.9 time = 655
.meas tran vdout1_32ck130 FIND v(dout1_32) AT=655.025n

* CHECK dout1_33 Vdout1_33ck130 = 0 time = 655
.meas tran vdout1_33ck130 FIND v(dout1_33) AT=655.025n

* CHECK dout1_34 Vdout1_34ck130 = 0.9 time = 655
.meas tran vdout1_34ck130 FIND v(dout1_34) AT=655.025n

* CHECK dout1_35 Vdout1_35ck130 = 0.9 time = 655
.meas tran vdout1_35ck130 FIND v(dout1_35) AT=655.025n

* CHECK dout1_36 Vdout1_36ck130 = 0.9 time = 655
.meas tran vdout1_36ck130 FIND v(dout1_36) AT=655.025n

* CHECK dout1_37 Vdout1_37ck130 = 0.9 time = 655
.meas tran vdout1_37ck130 FIND v(dout1_37) AT=655.025n

* CHECK dout1_38 Vdout1_38ck130 = 0 time = 655
.meas tran vdout1_38ck130 FIND v(dout1_38) AT=655.025n

* CHECK dout1_39 Vdout1_39ck130 = 0 time = 655
.meas tran vdout1_39ck130 FIND v(dout1_39) AT=655.025n

* CHECK dout1_40 Vdout1_40ck130 = 0 time = 655
.meas tran vdout1_40ck130 FIND v(dout1_40) AT=655.025n

* CHECK dout1_41 Vdout1_41ck130 = 0.9 time = 655
.meas tran vdout1_41ck130 FIND v(dout1_41) AT=655.025n

* CHECK dout1_42 Vdout1_42ck130 = 0 time = 655
.meas tran vdout1_42ck130 FIND v(dout1_42) AT=655.025n

* CHECK dout1_43 Vdout1_43ck130 = 0 time = 655
.meas tran vdout1_43ck130 FIND v(dout1_43) AT=655.025n

* CHECK dout1_44 Vdout1_44ck130 = 0.9 time = 655
.meas tran vdout1_44ck130 FIND v(dout1_44) AT=655.025n

* CHECK dout1_45 Vdout1_45ck130 = 0.9 time = 655
.meas tran vdout1_45ck130 FIND v(dout1_45) AT=655.025n

* CHECK dout1_46 Vdout1_46ck130 = 0.9 time = 655
.meas tran vdout1_46ck130 FIND v(dout1_46) AT=655.025n

* CHECK dout1_47 Vdout1_47ck130 = 0.9 time = 655
.meas tran vdout1_47ck130 FIND v(dout1_47) AT=655.025n

* CHECK dout1_48 Vdout1_48ck130 = 0.9 time = 655
.meas tran vdout1_48ck130 FIND v(dout1_48) AT=655.025n

* CHECK dout1_49 Vdout1_49ck130 = 0.9 time = 655
.meas tran vdout1_49ck130 FIND v(dout1_49) AT=655.025n

* CHECK dout1_50 Vdout1_50ck130 = 0 time = 655
.meas tran vdout1_50ck130 FIND v(dout1_50) AT=655.025n

* CHECK dout1_51 Vdout1_51ck130 = 0.9 time = 655
.meas tran vdout1_51ck130 FIND v(dout1_51) AT=655.025n

* CHECK dout1_52 Vdout1_52ck130 = 0 time = 655
.meas tran vdout1_52ck130 FIND v(dout1_52) AT=655.025n

* CHECK dout1_53 Vdout1_53ck130 = 0 time = 655
.meas tran vdout1_53ck130 FIND v(dout1_53) AT=655.025n

* CHECK dout1_54 Vdout1_54ck130 = 0 time = 655
.meas tran vdout1_54ck130 FIND v(dout1_54) AT=655.025n

* CHECK dout1_55 Vdout1_55ck130 = 0 time = 655
.meas tran vdout1_55ck130 FIND v(dout1_55) AT=655.025n

* CHECK dout1_56 Vdout1_56ck130 = 0 time = 655
.meas tran vdout1_56ck130 FIND v(dout1_56) AT=655.025n

* CHECK dout1_57 Vdout1_57ck130 = 0.9 time = 655
.meas tran vdout1_57ck130 FIND v(dout1_57) AT=655.025n

* CHECK dout1_58 Vdout1_58ck130 = 0 time = 655
.meas tran vdout1_58ck130 FIND v(dout1_58) AT=655.025n

* CHECK dout1_59 Vdout1_59ck130 = 0 time = 655
.meas tran vdout1_59ck130 FIND v(dout1_59) AT=655.025n

* CHECK dout1_60 Vdout1_60ck130 = 0.9 time = 655
.meas tran vdout1_60ck130 FIND v(dout1_60) AT=655.025n

* CHECK dout1_61 Vdout1_61ck130 = 0.9 time = 655
.meas tran vdout1_61ck130 FIND v(dout1_61) AT=655.025n

* CHECK dout1_62 Vdout1_62ck130 = 0 time = 655
.meas tran vdout1_62ck130 FIND v(dout1_62) AT=655.025n

* CHECK dout1_63 Vdout1_63ck130 = 0 time = 655
.meas tran vdout1_63ck130 FIND v(dout1_63) AT=655.025n

* CHECK dout1_64 Vdout1_64ck130 = 0 time = 655
.meas tran vdout1_64ck130 FIND v(dout1_64) AT=655.025n

* CHECK dout1_65 Vdout1_65ck130 = 0 time = 655
.meas tran vdout1_65ck130 FIND v(dout1_65) AT=655.025n

* CHECK dout1_66 Vdout1_66ck130 = 0.9 time = 655
.meas tran vdout1_66ck130 FIND v(dout1_66) AT=655.025n

* CHECK dout1_67 Vdout1_67ck130 = 0 time = 655
.meas tran vdout1_67ck130 FIND v(dout1_67) AT=655.025n

* CHECK dout1_68 Vdout1_68ck130 = 0.9 time = 655
.meas tran vdout1_68ck130 FIND v(dout1_68) AT=655.025n

* CHECK dout1_69 Vdout1_69ck130 = 0 time = 655
.meas tran vdout1_69ck130 FIND v(dout1_69) AT=655.025n

* CHECK dout1_70 Vdout1_70ck130 = 0 time = 655
.meas tran vdout1_70ck130 FIND v(dout1_70) AT=655.025n

* CHECK dout1_71 Vdout1_71ck130 = 0.9 time = 655
.meas tran vdout1_71ck130 FIND v(dout1_71) AT=655.025n

* CHECK dout1_72 Vdout1_72ck130 = 0 time = 655
.meas tran vdout1_72ck130 FIND v(dout1_72) AT=655.025n

* CHECK dout1_73 Vdout1_73ck130 = 0 time = 655
.meas tran vdout1_73ck130 FIND v(dout1_73) AT=655.025n

* CHECK dout1_74 Vdout1_74ck130 = 0.9 time = 655
.meas tran vdout1_74ck130 FIND v(dout1_74) AT=655.025n

* CHECK dout1_75 Vdout1_75ck130 = 0 time = 655
.meas tran vdout1_75ck130 FIND v(dout1_75) AT=655.025n

* CHECK dout1_76 Vdout1_76ck130 = 0 time = 655
.meas tran vdout1_76ck130 FIND v(dout1_76) AT=655.025n

* CHECK dout1_77 Vdout1_77ck130 = 0 time = 655
.meas tran vdout1_77ck130 FIND v(dout1_77) AT=655.025n

* CHECK dout1_78 Vdout1_78ck130 = 0.9 time = 655
.meas tran vdout1_78ck130 FIND v(dout1_78) AT=655.025n

* CHECK dout1_79 Vdout1_79ck130 = 0 time = 655
.meas tran vdout1_79ck130 FIND v(dout1_79) AT=655.025n

* CHECK dout1_80 Vdout1_80ck130 = 0.9 time = 655
.meas tran vdout1_80ck130 FIND v(dout1_80) AT=655.025n

* CHECK dout1_81 Vdout1_81ck130 = 0 time = 655
.meas tran vdout1_81ck130 FIND v(dout1_81) AT=655.025n

* CHECK dout1_82 Vdout1_82ck130 = 0.9 time = 655
.meas tran vdout1_82ck130 FIND v(dout1_82) AT=655.025n

* CHECK dout1_83 Vdout1_83ck130 = 0 time = 655
.meas tran vdout1_83ck130 FIND v(dout1_83) AT=655.025n

* CHECK dout1_84 Vdout1_84ck130 = 0 time = 655
.meas tran vdout1_84ck130 FIND v(dout1_84) AT=655.025n

* CHECK dout1_85 Vdout1_85ck130 = 0 time = 655
.meas tran vdout1_85ck130 FIND v(dout1_85) AT=655.025n

* CHECK dout1_86 Vdout1_86ck130 = 0 time = 655
.meas tran vdout1_86ck130 FIND v(dout1_86) AT=655.025n

* CHECK dout1_87 Vdout1_87ck130 = 0.9 time = 655
.meas tran vdout1_87ck130 FIND v(dout1_87) AT=655.025n

* CHECK dout1_88 Vdout1_88ck130 = 0 time = 655
.meas tran vdout1_88ck130 FIND v(dout1_88) AT=655.025n

* CHECK dout1_89 Vdout1_89ck130 = 0.9 time = 655
.meas tran vdout1_89ck130 FIND v(dout1_89) AT=655.025n

* CHECK dout1_90 Vdout1_90ck130 = 0 time = 655
.meas tran vdout1_90ck130 FIND v(dout1_90) AT=655.025n

* CHECK dout1_91 Vdout1_91ck130 = 0.9 time = 655
.meas tran vdout1_91ck130 FIND v(dout1_91) AT=655.025n

* CHECK dout1_92 Vdout1_92ck130 = 0.9 time = 655
.meas tran vdout1_92ck130 FIND v(dout1_92) AT=655.025n

* CHECK dout1_93 Vdout1_93ck130 = 0 time = 655
.meas tran vdout1_93ck130 FIND v(dout1_93) AT=655.025n

* CHECK dout1_94 Vdout1_94ck130 = 0 time = 655
.meas tran vdout1_94ck130 FIND v(dout1_94) AT=655.025n

* CHECK dout1_95 Vdout1_95ck130 = 0 time = 655
.meas tran vdout1_95ck130 FIND v(dout1_95) AT=655.025n

* CHECK dout1_96 Vdout1_96ck130 = 0 time = 655
.meas tran vdout1_96ck130 FIND v(dout1_96) AT=655.025n

* CHECK dout1_97 Vdout1_97ck130 = 0.9 time = 655
.meas tran vdout1_97ck130 FIND v(dout1_97) AT=655.025n

* CHECK dout1_98 Vdout1_98ck130 = 0 time = 655
.meas tran vdout1_98ck130 FIND v(dout1_98) AT=655.025n

* CHECK dout1_99 Vdout1_99ck130 = 0 time = 655
.meas tran vdout1_99ck130 FIND v(dout1_99) AT=655.025n

* CHECK dout1_100 Vdout1_100ck130 = 0.9 time = 655
.meas tran vdout1_100ck130 FIND v(dout1_100) AT=655.025n

* CHECK dout1_101 Vdout1_101ck130 = 0.9 time = 655
.meas tran vdout1_101ck130 FIND v(dout1_101) AT=655.025n

* CHECK dout1_102 Vdout1_102ck130 = 0 time = 655
.meas tran vdout1_102ck130 FIND v(dout1_102) AT=655.025n

* CHECK dout1_103 Vdout1_103ck130 = 0.9 time = 655
.meas tran vdout1_103ck130 FIND v(dout1_103) AT=655.025n

* CHECK dout1_104 Vdout1_104ck130 = 0 time = 655
.meas tran vdout1_104ck130 FIND v(dout1_104) AT=655.025n

* CHECK dout1_105 Vdout1_105ck130 = 0.9 time = 655
.meas tran vdout1_105ck130 FIND v(dout1_105) AT=655.025n

* CHECK dout1_106 Vdout1_106ck130 = 0 time = 655
.meas tran vdout1_106ck130 FIND v(dout1_106) AT=655.025n

* CHECK dout1_107 Vdout1_107ck130 = 0 time = 655
.meas tran vdout1_107ck130 FIND v(dout1_107) AT=655.025n

* CHECK dout1_108 Vdout1_108ck130 = 0 time = 655
.meas tran vdout1_108ck130 FIND v(dout1_108) AT=655.025n

* CHECK dout1_109 Vdout1_109ck130 = 0.9 time = 655
.meas tran vdout1_109ck130 FIND v(dout1_109) AT=655.025n

* CHECK dout1_110 Vdout1_110ck130 = 0 time = 655
.meas tran vdout1_110ck130 FIND v(dout1_110) AT=655.025n

* CHECK dout1_111 Vdout1_111ck130 = 0 time = 655
.meas tran vdout1_111ck130 FIND v(dout1_111) AT=655.025n

* CHECK dout1_112 Vdout1_112ck130 = 0 time = 655
.meas tran vdout1_112ck130 FIND v(dout1_112) AT=655.025n

* CHECK dout1_113 Vdout1_113ck130 = 0.9 time = 655
.meas tran vdout1_113ck130 FIND v(dout1_113) AT=655.025n

* CHECK dout1_114 Vdout1_114ck130 = 0 time = 655
.meas tran vdout1_114ck130 FIND v(dout1_114) AT=655.025n

* CHECK dout1_115 Vdout1_115ck130 = 0.9 time = 655
.meas tran vdout1_115ck130 FIND v(dout1_115) AT=655.025n

* CHECK dout1_116 Vdout1_116ck130 = 0.9 time = 655
.meas tran vdout1_116ck130 FIND v(dout1_116) AT=655.025n

* CHECK dout1_117 Vdout1_117ck130 = 0.9 time = 655
.meas tran vdout1_117ck130 FIND v(dout1_117) AT=655.025n

* CHECK dout1_118 Vdout1_118ck130 = 0.9 time = 655
.meas tran vdout1_118ck130 FIND v(dout1_118) AT=655.025n

* CHECK dout1_119 Vdout1_119ck130 = 0 time = 655
.meas tran vdout1_119ck130 FIND v(dout1_119) AT=655.025n

* CHECK dout1_0 Vdout1_0ck132 = 0 time = 665
.meas tran vdout1_0ck132 FIND v(dout1_0) AT=665.025n

* CHECK dout1_1 Vdout1_1ck132 = 0.9 time = 665
.meas tran vdout1_1ck132 FIND v(dout1_1) AT=665.025n

* CHECK dout1_2 Vdout1_2ck132 = 0.9 time = 665
.meas tran vdout1_2ck132 FIND v(dout1_2) AT=665.025n

* CHECK dout1_3 Vdout1_3ck132 = 0.9 time = 665
.meas tran vdout1_3ck132 FIND v(dout1_3) AT=665.025n

* CHECK dout1_4 Vdout1_4ck132 = 0 time = 665
.meas tran vdout1_4ck132 FIND v(dout1_4) AT=665.025n

* CHECK dout1_5 Vdout1_5ck132 = 0.9 time = 665
.meas tran vdout1_5ck132 FIND v(dout1_5) AT=665.025n

* CHECK dout1_6 Vdout1_6ck132 = 0 time = 665
.meas tran vdout1_6ck132 FIND v(dout1_6) AT=665.025n

* CHECK dout1_7 Vdout1_7ck132 = 0 time = 665
.meas tran vdout1_7ck132 FIND v(dout1_7) AT=665.025n

* CHECK dout1_8 Vdout1_8ck132 = 0.9 time = 665
.meas tran vdout1_8ck132 FIND v(dout1_8) AT=665.025n

* CHECK dout1_9 Vdout1_9ck132 = 0 time = 665
.meas tran vdout1_9ck132 FIND v(dout1_9) AT=665.025n

* CHECK dout1_10 Vdout1_10ck132 = 0 time = 665
.meas tran vdout1_10ck132 FIND v(dout1_10) AT=665.025n

* CHECK dout1_11 Vdout1_11ck132 = 0 time = 665
.meas tran vdout1_11ck132 FIND v(dout1_11) AT=665.025n

* CHECK dout1_12 Vdout1_12ck132 = 0 time = 665
.meas tran vdout1_12ck132 FIND v(dout1_12) AT=665.025n

* CHECK dout1_13 Vdout1_13ck132 = 0 time = 665
.meas tran vdout1_13ck132 FIND v(dout1_13) AT=665.025n

* CHECK dout1_14 Vdout1_14ck132 = 0.9 time = 665
.meas tran vdout1_14ck132 FIND v(dout1_14) AT=665.025n

* CHECK dout1_15 Vdout1_15ck132 = 0.9 time = 665
.meas tran vdout1_15ck132 FIND v(dout1_15) AT=665.025n

* CHECK dout1_16 Vdout1_16ck132 = 0 time = 665
.meas tran vdout1_16ck132 FIND v(dout1_16) AT=665.025n

* CHECK dout1_17 Vdout1_17ck132 = 0 time = 665
.meas tran vdout1_17ck132 FIND v(dout1_17) AT=665.025n

* CHECK dout1_18 Vdout1_18ck132 = 0 time = 665
.meas tran vdout1_18ck132 FIND v(dout1_18) AT=665.025n

* CHECK dout1_19 Vdout1_19ck132 = 0 time = 665
.meas tran vdout1_19ck132 FIND v(dout1_19) AT=665.025n

* CHECK dout1_20 Vdout1_20ck132 = 0.9 time = 665
.meas tran vdout1_20ck132 FIND v(dout1_20) AT=665.025n

* CHECK dout1_21 Vdout1_21ck132 = 0.9 time = 665
.meas tran vdout1_21ck132 FIND v(dout1_21) AT=665.025n

* CHECK dout1_22 Vdout1_22ck132 = 0 time = 665
.meas tran vdout1_22ck132 FIND v(dout1_22) AT=665.025n

* CHECK dout1_23 Vdout1_23ck132 = 0.9 time = 665
.meas tran vdout1_23ck132 FIND v(dout1_23) AT=665.025n

* CHECK dout1_24 Vdout1_24ck132 = 0.9 time = 665
.meas tran vdout1_24ck132 FIND v(dout1_24) AT=665.025n

* CHECK dout1_25 Vdout1_25ck132 = 0 time = 665
.meas tran vdout1_25ck132 FIND v(dout1_25) AT=665.025n

* CHECK dout1_26 Vdout1_26ck132 = 0.9 time = 665
.meas tran vdout1_26ck132 FIND v(dout1_26) AT=665.025n

* CHECK dout1_27 Vdout1_27ck132 = 0 time = 665
.meas tran vdout1_27ck132 FIND v(dout1_27) AT=665.025n

* CHECK dout1_28 Vdout1_28ck132 = 0 time = 665
.meas tran vdout1_28ck132 FIND v(dout1_28) AT=665.025n

* CHECK dout1_29 Vdout1_29ck132 = 0 time = 665
.meas tran vdout1_29ck132 FIND v(dout1_29) AT=665.025n

* CHECK dout1_30 Vdout1_30ck132 = 0 time = 665
.meas tran vdout1_30ck132 FIND v(dout1_30) AT=665.025n

* CHECK dout1_31 Vdout1_31ck132 = 0 time = 665
.meas tran vdout1_31ck132 FIND v(dout1_31) AT=665.025n

* CHECK dout1_32 Vdout1_32ck132 = 0 time = 665
.meas tran vdout1_32ck132 FIND v(dout1_32) AT=665.025n

* CHECK dout1_33 Vdout1_33ck132 = 0 time = 665
.meas tran vdout1_33ck132 FIND v(dout1_33) AT=665.025n

* CHECK dout1_34 Vdout1_34ck132 = 0.9 time = 665
.meas tran vdout1_34ck132 FIND v(dout1_34) AT=665.025n

* CHECK dout1_35 Vdout1_35ck132 = 0.9 time = 665
.meas tran vdout1_35ck132 FIND v(dout1_35) AT=665.025n

* CHECK dout1_36 Vdout1_36ck132 = 0 time = 665
.meas tran vdout1_36ck132 FIND v(dout1_36) AT=665.025n

* CHECK dout1_37 Vdout1_37ck132 = 0 time = 665
.meas tran vdout1_37ck132 FIND v(dout1_37) AT=665.025n

* CHECK dout1_38 Vdout1_38ck132 = 0 time = 665
.meas tran vdout1_38ck132 FIND v(dout1_38) AT=665.025n

* CHECK dout1_39 Vdout1_39ck132 = 0.9 time = 665
.meas tran vdout1_39ck132 FIND v(dout1_39) AT=665.025n

* CHECK dout1_40 Vdout1_40ck132 = 0 time = 665
.meas tran vdout1_40ck132 FIND v(dout1_40) AT=665.025n

* CHECK dout1_41 Vdout1_41ck132 = 0.9 time = 665
.meas tran vdout1_41ck132 FIND v(dout1_41) AT=665.025n

* CHECK dout1_42 Vdout1_42ck132 = 0.9 time = 665
.meas tran vdout1_42ck132 FIND v(dout1_42) AT=665.025n

* CHECK dout1_43 Vdout1_43ck132 = 0 time = 665
.meas tran vdout1_43ck132 FIND v(dout1_43) AT=665.025n

* CHECK dout1_44 Vdout1_44ck132 = 0.9 time = 665
.meas tran vdout1_44ck132 FIND v(dout1_44) AT=665.025n

* CHECK dout1_45 Vdout1_45ck132 = 0 time = 665
.meas tran vdout1_45ck132 FIND v(dout1_45) AT=665.025n

* CHECK dout1_46 Vdout1_46ck132 = 0.9 time = 665
.meas tran vdout1_46ck132 FIND v(dout1_46) AT=665.025n

* CHECK dout1_47 Vdout1_47ck132 = 0 time = 665
.meas tran vdout1_47ck132 FIND v(dout1_47) AT=665.025n

* CHECK dout1_48 Vdout1_48ck132 = 0.9 time = 665
.meas tran vdout1_48ck132 FIND v(dout1_48) AT=665.025n

* CHECK dout1_49 Vdout1_49ck132 = 0.9 time = 665
.meas tran vdout1_49ck132 FIND v(dout1_49) AT=665.025n

* CHECK dout1_50 Vdout1_50ck132 = 0 time = 665
.meas tran vdout1_50ck132 FIND v(dout1_50) AT=665.025n

* CHECK dout1_51 Vdout1_51ck132 = 0 time = 665
.meas tran vdout1_51ck132 FIND v(dout1_51) AT=665.025n

* CHECK dout1_52 Vdout1_52ck132 = 0.9 time = 665
.meas tran vdout1_52ck132 FIND v(dout1_52) AT=665.025n

* CHECK dout1_53 Vdout1_53ck132 = 0.9 time = 665
.meas tran vdout1_53ck132 FIND v(dout1_53) AT=665.025n

* CHECK dout1_54 Vdout1_54ck132 = 0.9 time = 665
.meas tran vdout1_54ck132 FIND v(dout1_54) AT=665.025n

* CHECK dout1_55 Vdout1_55ck132 = 0.9 time = 665
.meas tran vdout1_55ck132 FIND v(dout1_55) AT=665.025n

* CHECK dout1_56 Vdout1_56ck132 = 0.9 time = 665
.meas tran vdout1_56ck132 FIND v(dout1_56) AT=665.025n

* CHECK dout1_57 Vdout1_57ck132 = 0 time = 665
.meas tran vdout1_57ck132 FIND v(dout1_57) AT=665.025n

* CHECK dout1_58 Vdout1_58ck132 = 0.9 time = 665
.meas tran vdout1_58ck132 FIND v(dout1_58) AT=665.025n

* CHECK dout1_59 Vdout1_59ck132 = 0 time = 665
.meas tran vdout1_59ck132 FIND v(dout1_59) AT=665.025n

* CHECK dout1_60 Vdout1_60ck132 = 0.9 time = 665
.meas tran vdout1_60ck132 FIND v(dout1_60) AT=665.025n

* CHECK dout1_61 Vdout1_61ck132 = 0.9 time = 665
.meas tran vdout1_61ck132 FIND v(dout1_61) AT=665.025n

* CHECK dout1_62 Vdout1_62ck132 = 0 time = 665
.meas tran vdout1_62ck132 FIND v(dout1_62) AT=665.025n

* CHECK dout1_63 Vdout1_63ck132 = 0 time = 665
.meas tran vdout1_63ck132 FIND v(dout1_63) AT=665.025n

* CHECK dout1_64 Vdout1_64ck132 = 0.9 time = 665
.meas tran vdout1_64ck132 FIND v(dout1_64) AT=665.025n

* CHECK dout1_65 Vdout1_65ck132 = 0.9 time = 665
.meas tran vdout1_65ck132 FIND v(dout1_65) AT=665.025n

* CHECK dout1_66 Vdout1_66ck132 = 0.9 time = 665
.meas tran vdout1_66ck132 FIND v(dout1_66) AT=665.025n

* CHECK dout1_67 Vdout1_67ck132 = 0.9 time = 665
.meas tran vdout1_67ck132 FIND v(dout1_67) AT=665.025n

* CHECK dout1_68 Vdout1_68ck132 = 0 time = 665
.meas tran vdout1_68ck132 FIND v(dout1_68) AT=665.025n

* CHECK dout1_69 Vdout1_69ck132 = 0.9 time = 665
.meas tran vdout1_69ck132 FIND v(dout1_69) AT=665.025n

* CHECK dout1_70 Vdout1_70ck132 = 0 time = 665
.meas tran vdout1_70ck132 FIND v(dout1_70) AT=665.025n

* CHECK dout1_71 Vdout1_71ck132 = 0 time = 665
.meas tran vdout1_71ck132 FIND v(dout1_71) AT=665.025n

* CHECK dout1_72 Vdout1_72ck132 = 0 time = 665
.meas tran vdout1_72ck132 FIND v(dout1_72) AT=665.025n

* CHECK dout1_73 Vdout1_73ck132 = 0.9 time = 665
.meas tran vdout1_73ck132 FIND v(dout1_73) AT=665.025n

* CHECK dout1_74 Vdout1_74ck132 = 0.9 time = 665
.meas tran vdout1_74ck132 FIND v(dout1_74) AT=665.025n

* CHECK dout1_75 Vdout1_75ck132 = 0.9 time = 665
.meas tran vdout1_75ck132 FIND v(dout1_75) AT=665.025n

* CHECK dout1_76 Vdout1_76ck132 = 0 time = 665
.meas tran vdout1_76ck132 FIND v(dout1_76) AT=665.025n

* CHECK dout1_77 Vdout1_77ck132 = 0 time = 665
.meas tran vdout1_77ck132 FIND v(dout1_77) AT=665.025n

* CHECK dout1_78 Vdout1_78ck132 = 0 time = 665
.meas tran vdout1_78ck132 FIND v(dout1_78) AT=665.025n

* CHECK dout1_79 Vdout1_79ck132 = 0 time = 665
.meas tran vdout1_79ck132 FIND v(dout1_79) AT=665.025n

* CHECK dout1_80 Vdout1_80ck132 = 0.9 time = 665
.meas tran vdout1_80ck132 FIND v(dout1_80) AT=665.025n

* CHECK dout1_81 Vdout1_81ck132 = 0 time = 665
.meas tran vdout1_81ck132 FIND v(dout1_81) AT=665.025n

* CHECK dout1_82 Vdout1_82ck132 = 0.9 time = 665
.meas tran vdout1_82ck132 FIND v(dout1_82) AT=665.025n

* CHECK dout1_83 Vdout1_83ck132 = 0.9 time = 665
.meas tran vdout1_83ck132 FIND v(dout1_83) AT=665.025n

* CHECK dout1_84 Vdout1_84ck132 = 0.9 time = 665
.meas tran vdout1_84ck132 FIND v(dout1_84) AT=665.025n

* CHECK dout1_85 Vdout1_85ck132 = 0.9 time = 665
.meas tran vdout1_85ck132 FIND v(dout1_85) AT=665.025n

* CHECK dout1_86 Vdout1_86ck132 = 0.9 time = 665
.meas tran vdout1_86ck132 FIND v(dout1_86) AT=665.025n

* CHECK dout1_87 Vdout1_87ck132 = 0.9 time = 665
.meas tran vdout1_87ck132 FIND v(dout1_87) AT=665.025n

* CHECK dout1_88 Vdout1_88ck132 = 0 time = 665
.meas tran vdout1_88ck132 FIND v(dout1_88) AT=665.025n

* CHECK dout1_89 Vdout1_89ck132 = 0.9 time = 665
.meas tran vdout1_89ck132 FIND v(dout1_89) AT=665.025n

* CHECK dout1_90 Vdout1_90ck132 = 0 time = 665
.meas tran vdout1_90ck132 FIND v(dout1_90) AT=665.025n

* CHECK dout1_91 Vdout1_91ck132 = 0.9 time = 665
.meas tran vdout1_91ck132 FIND v(dout1_91) AT=665.025n

* CHECK dout1_92 Vdout1_92ck132 = 0.9 time = 665
.meas tran vdout1_92ck132 FIND v(dout1_92) AT=665.025n

* CHECK dout1_93 Vdout1_93ck132 = 0 time = 665
.meas tran vdout1_93ck132 FIND v(dout1_93) AT=665.025n

* CHECK dout1_94 Vdout1_94ck132 = 0 time = 665
.meas tran vdout1_94ck132 FIND v(dout1_94) AT=665.025n

* CHECK dout1_95 Vdout1_95ck132 = 0.9 time = 665
.meas tran vdout1_95ck132 FIND v(dout1_95) AT=665.025n

* CHECK dout1_96 Vdout1_96ck132 = 0.9 time = 665
.meas tran vdout1_96ck132 FIND v(dout1_96) AT=665.025n

* CHECK dout1_97 Vdout1_97ck132 = 0 time = 665
.meas tran vdout1_97ck132 FIND v(dout1_97) AT=665.025n

* CHECK dout1_98 Vdout1_98ck132 = 0.9 time = 665
.meas tran vdout1_98ck132 FIND v(dout1_98) AT=665.025n

* CHECK dout1_99 Vdout1_99ck132 = 0 time = 665
.meas tran vdout1_99ck132 FIND v(dout1_99) AT=665.025n

* CHECK dout1_100 Vdout1_100ck132 = 0 time = 665
.meas tran vdout1_100ck132 FIND v(dout1_100) AT=665.025n

* CHECK dout1_101 Vdout1_101ck132 = 0 time = 665
.meas tran vdout1_101ck132 FIND v(dout1_101) AT=665.025n

* CHECK dout1_102 Vdout1_102ck132 = 0 time = 665
.meas tran vdout1_102ck132 FIND v(dout1_102) AT=665.025n

* CHECK dout1_103 Vdout1_103ck132 = 0 time = 665
.meas tran vdout1_103ck132 FIND v(dout1_103) AT=665.025n

* CHECK dout1_104 Vdout1_104ck132 = 0 time = 665
.meas tran vdout1_104ck132 FIND v(dout1_104) AT=665.025n

* CHECK dout1_105 Vdout1_105ck132 = 0 time = 665
.meas tran vdout1_105ck132 FIND v(dout1_105) AT=665.025n

* CHECK dout1_106 Vdout1_106ck132 = 0 time = 665
.meas tran vdout1_106ck132 FIND v(dout1_106) AT=665.025n

* CHECK dout1_107 Vdout1_107ck132 = 0 time = 665
.meas tran vdout1_107ck132 FIND v(dout1_107) AT=665.025n

* CHECK dout1_108 Vdout1_108ck132 = 0.9 time = 665
.meas tran vdout1_108ck132 FIND v(dout1_108) AT=665.025n

* CHECK dout1_109 Vdout1_109ck132 = 0.9 time = 665
.meas tran vdout1_109ck132 FIND v(dout1_109) AT=665.025n

* CHECK dout1_110 Vdout1_110ck132 = 0.9 time = 665
.meas tran vdout1_110ck132 FIND v(dout1_110) AT=665.025n

* CHECK dout1_111 Vdout1_111ck132 = 0 time = 665
.meas tran vdout1_111ck132 FIND v(dout1_111) AT=665.025n

* CHECK dout1_112 Vdout1_112ck132 = 0.9 time = 665
.meas tran vdout1_112ck132 FIND v(dout1_112) AT=665.025n

* CHECK dout1_113 Vdout1_113ck132 = 0 time = 665
.meas tran vdout1_113ck132 FIND v(dout1_113) AT=665.025n

* CHECK dout1_114 Vdout1_114ck132 = 0 time = 665
.meas tran vdout1_114ck132 FIND v(dout1_114) AT=665.025n

* CHECK dout1_115 Vdout1_115ck132 = 0.9 time = 665
.meas tran vdout1_115ck132 FIND v(dout1_115) AT=665.025n

* CHECK dout1_116 Vdout1_116ck132 = 0.9 time = 665
.meas tran vdout1_116ck132 FIND v(dout1_116) AT=665.025n

* CHECK dout1_117 Vdout1_117ck132 = 0 time = 665
.meas tran vdout1_117ck132 FIND v(dout1_117) AT=665.025n

* CHECK dout1_118 Vdout1_118ck132 = 0 time = 665
.meas tran vdout1_118ck132 FIND v(dout1_118) AT=665.025n

* CHECK dout1_119 Vdout1_119ck132 = 0.9 time = 665
.meas tran vdout1_119ck132 FIND v(dout1_119) AT=665.025n

* CHECK dout1_0 Vdout1_0ck134 = 0.9 time = 675
.meas tran vdout1_0ck134 FIND v(dout1_0) AT=675.025n

* CHECK dout1_1 Vdout1_1ck134 = 0 time = 675
.meas tran vdout1_1ck134 FIND v(dout1_1) AT=675.025n

* CHECK dout1_2 Vdout1_2ck134 = 0 time = 675
.meas tran vdout1_2ck134 FIND v(dout1_2) AT=675.025n

* CHECK dout1_3 Vdout1_3ck134 = 0 time = 675
.meas tran vdout1_3ck134 FIND v(dout1_3) AT=675.025n

* CHECK dout1_4 Vdout1_4ck134 = 0 time = 675
.meas tran vdout1_4ck134 FIND v(dout1_4) AT=675.025n

* CHECK dout1_5 Vdout1_5ck134 = 0 time = 675
.meas tran vdout1_5ck134 FIND v(dout1_5) AT=675.025n

* CHECK dout1_6 Vdout1_6ck134 = 0.9 time = 675
.meas tran vdout1_6ck134 FIND v(dout1_6) AT=675.025n

* CHECK dout1_7 Vdout1_7ck134 = 0.9 time = 675
.meas tran vdout1_7ck134 FIND v(dout1_7) AT=675.025n

* CHECK dout1_8 Vdout1_8ck134 = 0.9 time = 675
.meas tran vdout1_8ck134 FIND v(dout1_8) AT=675.025n

* CHECK dout1_9 Vdout1_9ck134 = 0.9 time = 675
.meas tran vdout1_9ck134 FIND v(dout1_9) AT=675.025n

* CHECK dout1_10 Vdout1_10ck134 = 0 time = 675
.meas tran vdout1_10ck134 FIND v(dout1_10) AT=675.025n

* CHECK dout1_11 Vdout1_11ck134 = 0 time = 675
.meas tran vdout1_11ck134 FIND v(dout1_11) AT=675.025n

* CHECK dout1_12 Vdout1_12ck134 = 0 time = 675
.meas tran vdout1_12ck134 FIND v(dout1_12) AT=675.025n

* CHECK dout1_13 Vdout1_13ck134 = 0 time = 675
.meas tran vdout1_13ck134 FIND v(dout1_13) AT=675.025n

* CHECK dout1_14 Vdout1_14ck134 = 0 time = 675
.meas tran vdout1_14ck134 FIND v(dout1_14) AT=675.025n

* CHECK dout1_15 Vdout1_15ck134 = 0.9 time = 675
.meas tran vdout1_15ck134 FIND v(dout1_15) AT=675.025n

* CHECK dout1_16 Vdout1_16ck134 = 0.9 time = 675
.meas tran vdout1_16ck134 FIND v(dout1_16) AT=675.025n

* CHECK dout1_17 Vdout1_17ck134 = 0 time = 675
.meas tran vdout1_17ck134 FIND v(dout1_17) AT=675.025n

* CHECK dout1_18 Vdout1_18ck134 = 0.9 time = 675
.meas tran vdout1_18ck134 FIND v(dout1_18) AT=675.025n

* CHECK dout1_19 Vdout1_19ck134 = 0 time = 675
.meas tran vdout1_19ck134 FIND v(dout1_19) AT=675.025n

* CHECK dout1_20 Vdout1_20ck134 = 0.9 time = 675
.meas tran vdout1_20ck134 FIND v(dout1_20) AT=675.025n

* CHECK dout1_21 Vdout1_21ck134 = 0 time = 675
.meas tran vdout1_21ck134 FIND v(dout1_21) AT=675.025n

* CHECK dout1_22 Vdout1_22ck134 = 0.9 time = 675
.meas tran vdout1_22ck134 FIND v(dout1_22) AT=675.025n

* CHECK dout1_23 Vdout1_23ck134 = 0 time = 675
.meas tran vdout1_23ck134 FIND v(dout1_23) AT=675.025n

* CHECK dout1_24 Vdout1_24ck134 = 0 time = 675
.meas tran vdout1_24ck134 FIND v(dout1_24) AT=675.025n

* CHECK dout1_25 Vdout1_25ck134 = 0.9 time = 675
.meas tran vdout1_25ck134 FIND v(dout1_25) AT=675.025n

* CHECK dout1_26 Vdout1_26ck134 = 0 time = 675
.meas tran vdout1_26ck134 FIND v(dout1_26) AT=675.025n

* CHECK dout1_27 Vdout1_27ck134 = 0 time = 675
.meas tran vdout1_27ck134 FIND v(dout1_27) AT=675.025n

* CHECK dout1_28 Vdout1_28ck134 = 0 time = 675
.meas tran vdout1_28ck134 FIND v(dout1_28) AT=675.025n

* CHECK dout1_29 Vdout1_29ck134 = 0 time = 675
.meas tran vdout1_29ck134 FIND v(dout1_29) AT=675.025n

* CHECK dout1_30 Vdout1_30ck134 = 0.9 time = 675
.meas tran vdout1_30ck134 FIND v(dout1_30) AT=675.025n

* CHECK dout1_31 Vdout1_31ck134 = 0 time = 675
.meas tran vdout1_31ck134 FIND v(dout1_31) AT=675.025n

* CHECK dout1_32 Vdout1_32ck134 = 0 time = 675
.meas tran vdout1_32ck134 FIND v(dout1_32) AT=675.025n

* CHECK dout1_33 Vdout1_33ck134 = 0 time = 675
.meas tran vdout1_33ck134 FIND v(dout1_33) AT=675.025n

* CHECK dout1_34 Vdout1_34ck134 = 0 time = 675
.meas tran vdout1_34ck134 FIND v(dout1_34) AT=675.025n

* CHECK dout1_35 Vdout1_35ck134 = 0 time = 675
.meas tran vdout1_35ck134 FIND v(dout1_35) AT=675.025n

* CHECK dout1_36 Vdout1_36ck134 = 0 time = 675
.meas tran vdout1_36ck134 FIND v(dout1_36) AT=675.025n

* CHECK dout1_37 Vdout1_37ck134 = 0.9 time = 675
.meas tran vdout1_37ck134 FIND v(dout1_37) AT=675.025n

* CHECK dout1_38 Vdout1_38ck134 = 0.9 time = 675
.meas tran vdout1_38ck134 FIND v(dout1_38) AT=675.025n

* CHECK dout1_39 Vdout1_39ck134 = 0 time = 675
.meas tran vdout1_39ck134 FIND v(dout1_39) AT=675.025n

* CHECK dout1_40 Vdout1_40ck134 = 0.9 time = 675
.meas tran vdout1_40ck134 FIND v(dout1_40) AT=675.025n

* CHECK dout1_41 Vdout1_41ck134 = 0.9 time = 675
.meas tran vdout1_41ck134 FIND v(dout1_41) AT=675.025n

* CHECK dout1_42 Vdout1_42ck134 = 0.9 time = 675
.meas tran vdout1_42ck134 FIND v(dout1_42) AT=675.025n

* CHECK dout1_43 Vdout1_43ck134 = 0.9 time = 675
.meas tran vdout1_43ck134 FIND v(dout1_43) AT=675.025n

* CHECK dout1_44 Vdout1_44ck134 = 0 time = 675
.meas tran vdout1_44ck134 FIND v(dout1_44) AT=675.025n

* CHECK dout1_45 Vdout1_45ck134 = 0.9 time = 675
.meas tran vdout1_45ck134 FIND v(dout1_45) AT=675.025n

* CHECK dout1_46 Vdout1_46ck134 = 0.9 time = 675
.meas tran vdout1_46ck134 FIND v(dout1_46) AT=675.025n

* CHECK dout1_47 Vdout1_47ck134 = 0.9 time = 675
.meas tran vdout1_47ck134 FIND v(dout1_47) AT=675.025n

* CHECK dout1_48 Vdout1_48ck134 = 0.9 time = 675
.meas tran vdout1_48ck134 FIND v(dout1_48) AT=675.025n

* CHECK dout1_49 Vdout1_49ck134 = 0 time = 675
.meas tran vdout1_49ck134 FIND v(dout1_49) AT=675.025n

* CHECK dout1_50 Vdout1_50ck134 = 0 time = 675
.meas tran vdout1_50ck134 FIND v(dout1_50) AT=675.025n

* CHECK dout1_51 Vdout1_51ck134 = 0 time = 675
.meas tran vdout1_51ck134 FIND v(dout1_51) AT=675.025n

* CHECK dout1_52 Vdout1_52ck134 = 0 time = 675
.meas tran vdout1_52ck134 FIND v(dout1_52) AT=675.025n

* CHECK dout1_53 Vdout1_53ck134 = 0 time = 675
.meas tran vdout1_53ck134 FIND v(dout1_53) AT=675.025n

* CHECK dout1_54 Vdout1_54ck134 = 0.9 time = 675
.meas tran vdout1_54ck134 FIND v(dout1_54) AT=675.025n

* CHECK dout1_55 Vdout1_55ck134 = 0.9 time = 675
.meas tran vdout1_55ck134 FIND v(dout1_55) AT=675.025n

* CHECK dout1_56 Vdout1_56ck134 = 0 time = 675
.meas tran vdout1_56ck134 FIND v(dout1_56) AT=675.025n

* CHECK dout1_57 Vdout1_57ck134 = 0 time = 675
.meas tran vdout1_57ck134 FIND v(dout1_57) AT=675.025n

* CHECK dout1_58 Vdout1_58ck134 = 0 time = 675
.meas tran vdout1_58ck134 FIND v(dout1_58) AT=675.025n

* CHECK dout1_59 Vdout1_59ck134 = 0 time = 675
.meas tran vdout1_59ck134 FIND v(dout1_59) AT=675.025n

* CHECK dout1_60 Vdout1_60ck134 = 0 time = 675
.meas tran vdout1_60ck134 FIND v(dout1_60) AT=675.025n

* CHECK dout1_61 Vdout1_61ck134 = 0.9 time = 675
.meas tran vdout1_61ck134 FIND v(dout1_61) AT=675.025n

* CHECK dout1_62 Vdout1_62ck134 = 0.9 time = 675
.meas tran vdout1_62ck134 FIND v(dout1_62) AT=675.025n

* CHECK dout1_63 Vdout1_63ck134 = 0 time = 675
.meas tran vdout1_63ck134 FIND v(dout1_63) AT=675.025n

* CHECK dout1_64 Vdout1_64ck134 = 0.9 time = 675
.meas tran vdout1_64ck134 FIND v(dout1_64) AT=675.025n

* CHECK dout1_65 Vdout1_65ck134 = 0 time = 675
.meas tran vdout1_65ck134 FIND v(dout1_65) AT=675.025n

* CHECK dout1_66 Vdout1_66ck134 = 0 time = 675
.meas tran vdout1_66ck134 FIND v(dout1_66) AT=675.025n

* CHECK dout1_67 Vdout1_67ck134 = 0 time = 675
.meas tran vdout1_67ck134 FIND v(dout1_67) AT=675.025n

* CHECK dout1_68 Vdout1_68ck134 = 0 time = 675
.meas tran vdout1_68ck134 FIND v(dout1_68) AT=675.025n

* CHECK dout1_69 Vdout1_69ck134 = 0 time = 675
.meas tran vdout1_69ck134 FIND v(dout1_69) AT=675.025n

* CHECK dout1_70 Vdout1_70ck134 = 0 time = 675
.meas tran vdout1_70ck134 FIND v(dout1_70) AT=675.025n

* CHECK dout1_71 Vdout1_71ck134 = 0 time = 675
.meas tran vdout1_71ck134 FIND v(dout1_71) AT=675.025n

* CHECK dout1_72 Vdout1_72ck134 = 0 time = 675
.meas tran vdout1_72ck134 FIND v(dout1_72) AT=675.025n

* CHECK dout1_73 Vdout1_73ck134 = 0 time = 675
.meas tran vdout1_73ck134 FIND v(dout1_73) AT=675.025n

* CHECK dout1_74 Vdout1_74ck134 = 0.9 time = 675
.meas tran vdout1_74ck134 FIND v(dout1_74) AT=675.025n

* CHECK dout1_75 Vdout1_75ck134 = 0 time = 675
.meas tran vdout1_75ck134 FIND v(dout1_75) AT=675.025n

* CHECK dout1_76 Vdout1_76ck134 = 0 time = 675
.meas tran vdout1_76ck134 FIND v(dout1_76) AT=675.025n

* CHECK dout1_77 Vdout1_77ck134 = 0 time = 675
.meas tran vdout1_77ck134 FIND v(dout1_77) AT=675.025n

* CHECK dout1_78 Vdout1_78ck134 = 0.9 time = 675
.meas tran vdout1_78ck134 FIND v(dout1_78) AT=675.025n

* CHECK dout1_79 Vdout1_79ck134 = 0 time = 675
.meas tran vdout1_79ck134 FIND v(dout1_79) AT=675.025n

* CHECK dout1_80 Vdout1_80ck134 = 0.9 time = 675
.meas tran vdout1_80ck134 FIND v(dout1_80) AT=675.025n

* CHECK dout1_81 Vdout1_81ck134 = 0.9 time = 675
.meas tran vdout1_81ck134 FIND v(dout1_81) AT=675.025n

* CHECK dout1_82 Vdout1_82ck134 = 0.9 time = 675
.meas tran vdout1_82ck134 FIND v(dout1_82) AT=675.025n

* CHECK dout1_83 Vdout1_83ck134 = 0.9 time = 675
.meas tran vdout1_83ck134 FIND v(dout1_83) AT=675.025n

* CHECK dout1_84 Vdout1_84ck134 = 0.9 time = 675
.meas tran vdout1_84ck134 FIND v(dout1_84) AT=675.025n

* CHECK dout1_85 Vdout1_85ck134 = 0 time = 675
.meas tran vdout1_85ck134 FIND v(dout1_85) AT=675.025n

* CHECK dout1_86 Vdout1_86ck134 = 0 time = 675
.meas tran vdout1_86ck134 FIND v(dout1_86) AT=675.025n

* CHECK dout1_87 Vdout1_87ck134 = 0.9 time = 675
.meas tran vdout1_87ck134 FIND v(dout1_87) AT=675.025n

* CHECK dout1_88 Vdout1_88ck134 = 0 time = 675
.meas tran vdout1_88ck134 FIND v(dout1_88) AT=675.025n

* CHECK dout1_89 Vdout1_89ck134 = 0 time = 675
.meas tran vdout1_89ck134 FIND v(dout1_89) AT=675.025n

* CHECK dout1_90 Vdout1_90ck134 = 0.9 time = 675
.meas tran vdout1_90ck134 FIND v(dout1_90) AT=675.025n

* CHECK dout1_91 Vdout1_91ck134 = 0.9 time = 675
.meas tran vdout1_91ck134 FIND v(dout1_91) AT=675.025n

* CHECK dout1_92 Vdout1_92ck134 = 0 time = 675
.meas tran vdout1_92ck134 FIND v(dout1_92) AT=675.025n

* CHECK dout1_93 Vdout1_93ck134 = 0 time = 675
.meas tran vdout1_93ck134 FIND v(dout1_93) AT=675.025n

* CHECK dout1_94 Vdout1_94ck134 = 0.9 time = 675
.meas tran vdout1_94ck134 FIND v(dout1_94) AT=675.025n

* CHECK dout1_95 Vdout1_95ck134 = 0.9 time = 675
.meas tran vdout1_95ck134 FIND v(dout1_95) AT=675.025n

* CHECK dout1_96 Vdout1_96ck134 = 0.9 time = 675
.meas tran vdout1_96ck134 FIND v(dout1_96) AT=675.025n

* CHECK dout1_97 Vdout1_97ck134 = 0 time = 675
.meas tran vdout1_97ck134 FIND v(dout1_97) AT=675.025n

* CHECK dout1_98 Vdout1_98ck134 = 0.9 time = 675
.meas tran vdout1_98ck134 FIND v(dout1_98) AT=675.025n

* CHECK dout1_99 Vdout1_99ck134 = 0.9 time = 675
.meas tran vdout1_99ck134 FIND v(dout1_99) AT=675.025n

* CHECK dout1_100 Vdout1_100ck134 = 0 time = 675
.meas tran vdout1_100ck134 FIND v(dout1_100) AT=675.025n

* CHECK dout1_101 Vdout1_101ck134 = 0 time = 675
.meas tran vdout1_101ck134 FIND v(dout1_101) AT=675.025n

* CHECK dout1_102 Vdout1_102ck134 = 0 time = 675
.meas tran vdout1_102ck134 FIND v(dout1_102) AT=675.025n

* CHECK dout1_103 Vdout1_103ck134 = 0 time = 675
.meas tran vdout1_103ck134 FIND v(dout1_103) AT=675.025n

* CHECK dout1_104 Vdout1_104ck134 = 0 time = 675
.meas tran vdout1_104ck134 FIND v(dout1_104) AT=675.025n

* CHECK dout1_105 Vdout1_105ck134 = 0.9 time = 675
.meas tran vdout1_105ck134 FIND v(dout1_105) AT=675.025n

* CHECK dout1_106 Vdout1_106ck134 = 0.9 time = 675
.meas tran vdout1_106ck134 FIND v(dout1_106) AT=675.025n

* CHECK dout1_107 Vdout1_107ck134 = 0.9 time = 675
.meas tran vdout1_107ck134 FIND v(dout1_107) AT=675.025n

* CHECK dout1_108 Vdout1_108ck134 = 0 time = 675
.meas tran vdout1_108ck134 FIND v(dout1_108) AT=675.025n

* CHECK dout1_109 Vdout1_109ck134 = 0.9 time = 675
.meas tran vdout1_109ck134 FIND v(dout1_109) AT=675.025n

* CHECK dout1_110 Vdout1_110ck134 = 0.9 time = 675
.meas tran vdout1_110ck134 FIND v(dout1_110) AT=675.025n

* CHECK dout1_111 Vdout1_111ck134 = 0 time = 675
.meas tran vdout1_111ck134 FIND v(dout1_111) AT=675.025n

* CHECK dout1_112 Vdout1_112ck134 = 0 time = 675
.meas tran vdout1_112ck134 FIND v(dout1_112) AT=675.025n

* CHECK dout1_113 Vdout1_113ck134 = 0.9 time = 675
.meas tran vdout1_113ck134 FIND v(dout1_113) AT=675.025n

* CHECK dout1_114 Vdout1_114ck134 = 0.9 time = 675
.meas tran vdout1_114ck134 FIND v(dout1_114) AT=675.025n

* CHECK dout1_115 Vdout1_115ck134 = 0 time = 675
.meas tran vdout1_115ck134 FIND v(dout1_115) AT=675.025n

* CHECK dout1_116 Vdout1_116ck134 = 0 time = 675
.meas tran vdout1_116ck134 FIND v(dout1_116) AT=675.025n

* CHECK dout1_117 Vdout1_117ck134 = 0 time = 675
.meas tran vdout1_117ck134 FIND v(dout1_117) AT=675.025n

* CHECK dout1_118 Vdout1_118ck134 = 0 time = 675
.meas tran vdout1_118ck134 FIND v(dout1_118) AT=675.025n

* CHECK dout1_119 Vdout1_119ck134 = 0 time = 675
.meas tran vdout1_119ck134 FIND v(dout1_119) AT=675.025n

* CHECK dout1_0 Vdout1_0ck135 = 0.9 time = 680
.meas tran vdout1_0ck135 FIND v(dout1_0) AT=680.025n

* CHECK dout1_1 Vdout1_1ck135 = 0 time = 680
.meas tran vdout1_1ck135 FIND v(dout1_1) AT=680.025n

* CHECK dout1_2 Vdout1_2ck135 = 0 time = 680
.meas tran vdout1_2ck135 FIND v(dout1_2) AT=680.025n

* CHECK dout1_3 Vdout1_3ck135 = 0 time = 680
.meas tran vdout1_3ck135 FIND v(dout1_3) AT=680.025n

* CHECK dout1_4 Vdout1_4ck135 = 0 time = 680
.meas tran vdout1_4ck135 FIND v(dout1_4) AT=680.025n

* CHECK dout1_5 Vdout1_5ck135 = 0 time = 680
.meas tran vdout1_5ck135 FIND v(dout1_5) AT=680.025n

* CHECK dout1_6 Vdout1_6ck135 = 0.9 time = 680
.meas tran vdout1_6ck135 FIND v(dout1_6) AT=680.025n

* CHECK dout1_7 Vdout1_7ck135 = 0.9 time = 680
.meas tran vdout1_7ck135 FIND v(dout1_7) AT=680.025n

* CHECK dout1_8 Vdout1_8ck135 = 0.9 time = 680
.meas tran vdout1_8ck135 FIND v(dout1_8) AT=680.025n

* CHECK dout1_9 Vdout1_9ck135 = 0.9 time = 680
.meas tran vdout1_9ck135 FIND v(dout1_9) AT=680.025n

* CHECK dout1_10 Vdout1_10ck135 = 0 time = 680
.meas tran vdout1_10ck135 FIND v(dout1_10) AT=680.025n

* CHECK dout1_11 Vdout1_11ck135 = 0 time = 680
.meas tran vdout1_11ck135 FIND v(dout1_11) AT=680.025n

* CHECK dout1_12 Vdout1_12ck135 = 0 time = 680
.meas tran vdout1_12ck135 FIND v(dout1_12) AT=680.025n

* CHECK dout1_13 Vdout1_13ck135 = 0 time = 680
.meas tran vdout1_13ck135 FIND v(dout1_13) AT=680.025n

* CHECK dout1_14 Vdout1_14ck135 = 0 time = 680
.meas tran vdout1_14ck135 FIND v(dout1_14) AT=680.025n

* CHECK dout1_15 Vdout1_15ck135 = 0.9 time = 680
.meas tran vdout1_15ck135 FIND v(dout1_15) AT=680.025n

* CHECK dout1_16 Vdout1_16ck135 = 0.9 time = 680
.meas tran vdout1_16ck135 FIND v(dout1_16) AT=680.025n

* CHECK dout1_17 Vdout1_17ck135 = 0 time = 680
.meas tran vdout1_17ck135 FIND v(dout1_17) AT=680.025n

* CHECK dout1_18 Vdout1_18ck135 = 0.9 time = 680
.meas tran vdout1_18ck135 FIND v(dout1_18) AT=680.025n

* CHECK dout1_19 Vdout1_19ck135 = 0 time = 680
.meas tran vdout1_19ck135 FIND v(dout1_19) AT=680.025n

* CHECK dout1_20 Vdout1_20ck135 = 0.9 time = 680
.meas tran vdout1_20ck135 FIND v(dout1_20) AT=680.025n

* CHECK dout1_21 Vdout1_21ck135 = 0 time = 680
.meas tran vdout1_21ck135 FIND v(dout1_21) AT=680.025n

* CHECK dout1_22 Vdout1_22ck135 = 0.9 time = 680
.meas tran vdout1_22ck135 FIND v(dout1_22) AT=680.025n

* CHECK dout1_23 Vdout1_23ck135 = 0 time = 680
.meas tran vdout1_23ck135 FIND v(dout1_23) AT=680.025n

* CHECK dout1_24 Vdout1_24ck135 = 0 time = 680
.meas tran vdout1_24ck135 FIND v(dout1_24) AT=680.025n

* CHECK dout1_25 Vdout1_25ck135 = 0.9 time = 680
.meas tran vdout1_25ck135 FIND v(dout1_25) AT=680.025n

* CHECK dout1_26 Vdout1_26ck135 = 0 time = 680
.meas tran vdout1_26ck135 FIND v(dout1_26) AT=680.025n

* CHECK dout1_27 Vdout1_27ck135 = 0 time = 680
.meas tran vdout1_27ck135 FIND v(dout1_27) AT=680.025n

* CHECK dout1_28 Vdout1_28ck135 = 0 time = 680
.meas tran vdout1_28ck135 FIND v(dout1_28) AT=680.025n

* CHECK dout1_29 Vdout1_29ck135 = 0 time = 680
.meas tran vdout1_29ck135 FIND v(dout1_29) AT=680.025n

* CHECK dout1_30 Vdout1_30ck135 = 0.9 time = 680
.meas tran vdout1_30ck135 FIND v(dout1_30) AT=680.025n

* CHECK dout1_31 Vdout1_31ck135 = 0 time = 680
.meas tran vdout1_31ck135 FIND v(dout1_31) AT=680.025n

* CHECK dout1_32 Vdout1_32ck135 = 0 time = 680
.meas tran vdout1_32ck135 FIND v(dout1_32) AT=680.025n

* CHECK dout1_33 Vdout1_33ck135 = 0 time = 680
.meas tran vdout1_33ck135 FIND v(dout1_33) AT=680.025n

* CHECK dout1_34 Vdout1_34ck135 = 0 time = 680
.meas tran vdout1_34ck135 FIND v(dout1_34) AT=680.025n

* CHECK dout1_35 Vdout1_35ck135 = 0 time = 680
.meas tran vdout1_35ck135 FIND v(dout1_35) AT=680.025n

* CHECK dout1_36 Vdout1_36ck135 = 0 time = 680
.meas tran vdout1_36ck135 FIND v(dout1_36) AT=680.025n

* CHECK dout1_37 Vdout1_37ck135 = 0.9 time = 680
.meas tran vdout1_37ck135 FIND v(dout1_37) AT=680.025n

* CHECK dout1_38 Vdout1_38ck135 = 0.9 time = 680
.meas tran vdout1_38ck135 FIND v(dout1_38) AT=680.025n

* CHECK dout1_39 Vdout1_39ck135 = 0 time = 680
.meas tran vdout1_39ck135 FIND v(dout1_39) AT=680.025n

* CHECK dout1_40 Vdout1_40ck135 = 0.9 time = 680
.meas tran vdout1_40ck135 FIND v(dout1_40) AT=680.025n

* CHECK dout1_41 Vdout1_41ck135 = 0.9 time = 680
.meas tran vdout1_41ck135 FIND v(dout1_41) AT=680.025n

* CHECK dout1_42 Vdout1_42ck135 = 0.9 time = 680
.meas tran vdout1_42ck135 FIND v(dout1_42) AT=680.025n

* CHECK dout1_43 Vdout1_43ck135 = 0.9 time = 680
.meas tran vdout1_43ck135 FIND v(dout1_43) AT=680.025n

* CHECK dout1_44 Vdout1_44ck135 = 0 time = 680
.meas tran vdout1_44ck135 FIND v(dout1_44) AT=680.025n

* CHECK dout1_45 Vdout1_45ck135 = 0.9 time = 680
.meas tran vdout1_45ck135 FIND v(dout1_45) AT=680.025n

* CHECK dout1_46 Vdout1_46ck135 = 0.9 time = 680
.meas tran vdout1_46ck135 FIND v(dout1_46) AT=680.025n

* CHECK dout1_47 Vdout1_47ck135 = 0.9 time = 680
.meas tran vdout1_47ck135 FIND v(dout1_47) AT=680.025n

* CHECK dout1_48 Vdout1_48ck135 = 0.9 time = 680
.meas tran vdout1_48ck135 FIND v(dout1_48) AT=680.025n

* CHECK dout1_49 Vdout1_49ck135 = 0 time = 680
.meas tran vdout1_49ck135 FIND v(dout1_49) AT=680.025n

* CHECK dout1_50 Vdout1_50ck135 = 0 time = 680
.meas tran vdout1_50ck135 FIND v(dout1_50) AT=680.025n

* CHECK dout1_51 Vdout1_51ck135 = 0 time = 680
.meas tran vdout1_51ck135 FIND v(dout1_51) AT=680.025n

* CHECK dout1_52 Vdout1_52ck135 = 0 time = 680
.meas tran vdout1_52ck135 FIND v(dout1_52) AT=680.025n

* CHECK dout1_53 Vdout1_53ck135 = 0 time = 680
.meas tran vdout1_53ck135 FIND v(dout1_53) AT=680.025n

* CHECK dout1_54 Vdout1_54ck135 = 0.9 time = 680
.meas tran vdout1_54ck135 FIND v(dout1_54) AT=680.025n

* CHECK dout1_55 Vdout1_55ck135 = 0.9 time = 680
.meas tran vdout1_55ck135 FIND v(dout1_55) AT=680.025n

* CHECK dout1_56 Vdout1_56ck135 = 0 time = 680
.meas tran vdout1_56ck135 FIND v(dout1_56) AT=680.025n

* CHECK dout1_57 Vdout1_57ck135 = 0 time = 680
.meas tran vdout1_57ck135 FIND v(dout1_57) AT=680.025n

* CHECK dout1_58 Vdout1_58ck135 = 0 time = 680
.meas tran vdout1_58ck135 FIND v(dout1_58) AT=680.025n

* CHECK dout1_59 Vdout1_59ck135 = 0 time = 680
.meas tran vdout1_59ck135 FIND v(dout1_59) AT=680.025n

* CHECK dout1_60 Vdout1_60ck135 = 0 time = 680
.meas tran vdout1_60ck135 FIND v(dout1_60) AT=680.025n

* CHECK dout1_61 Vdout1_61ck135 = 0.9 time = 680
.meas tran vdout1_61ck135 FIND v(dout1_61) AT=680.025n

* CHECK dout1_62 Vdout1_62ck135 = 0.9 time = 680
.meas tran vdout1_62ck135 FIND v(dout1_62) AT=680.025n

* CHECK dout1_63 Vdout1_63ck135 = 0 time = 680
.meas tran vdout1_63ck135 FIND v(dout1_63) AT=680.025n

* CHECK dout1_64 Vdout1_64ck135 = 0.9 time = 680
.meas tran vdout1_64ck135 FIND v(dout1_64) AT=680.025n

* CHECK dout1_65 Vdout1_65ck135 = 0 time = 680
.meas tran vdout1_65ck135 FIND v(dout1_65) AT=680.025n

* CHECK dout1_66 Vdout1_66ck135 = 0 time = 680
.meas tran vdout1_66ck135 FIND v(dout1_66) AT=680.025n

* CHECK dout1_67 Vdout1_67ck135 = 0 time = 680
.meas tran vdout1_67ck135 FIND v(dout1_67) AT=680.025n

* CHECK dout1_68 Vdout1_68ck135 = 0 time = 680
.meas tran vdout1_68ck135 FIND v(dout1_68) AT=680.025n

* CHECK dout1_69 Vdout1_69ck135 = 0 time = 680
.meas tran vdout1_69ck135 FIND v(dout1_69) AT=680.025n

* CHECK dout1_70 Vdout1_70ck135 = 0 time = 680
.meas tran vdout1_70ck135 FIND v(dout1_70) AT=680.025n

* CHECK dout1_71 Vdout1_71ck135 = 0 time = 680
.meas tran vdout1_71ck135 FIND v(dout1_71) AT=680.025n

* CHECK dout1_72 Vdout1_72ck135 = 0 time = 680
.meas tran vdout1_72ck135 FIND v(dout1_72) AT=680.025n

* CHECK dout1_73 Vdout1_73ck135 = 0 time = 680
.meas tran vdout1_73ck135 FIND v(dout1_73) AT=680.025n

* CHECK dout1_74 Vdout1_74ck135 = 0.9 time = 680
.meas tran vdout1_74ck135 FIND v(dout1_74) AT=680.025n

* CHECK dout1_75 Vdout1_75ck135 = 0 time = 680
.meas tran vdout1_75ck135 FIND v(dout1_75) AT=680.025n

* CHECK dout1_76 Vdout1_76ck135 = 0 time = 680
.meas tran vdout1_76ck135 FIND v(dout1_76) AT=680.025n

* CHECK dout1_77 Vdout1_77ck135 = 0 time = 680
.meas tran vdout1_77ck135 FIND v(dout1_77) AT=680.025n

* CHECK dout1_78 Vdout1_78ck135 = 0.9 time = 680
.meas tran vdout1_78ck135 FIND v(dout1_78) AT=680.025n

* CHECK dout1_79 Vdout1_79ck135 = 0 time = 680
.meas tran vdout1_79ck135 FIND v(dout1_79) AT=680.025n

* CHECK dout1_80 Vdout1_80ck135 = 0.9 time = 680
.meas tran vdout1_80ck135 FIND v(dout1_80) AT=680.025n

* CHECK dout1_81 Vdout1_81ck135 = 0.9 time = 680
.meas tran vdout1_81ck135 FIND v(dout1_81) AT=680.025n

* CHECK dout1_82 Vdout1_82ck135 = 0.9 time = 680
.meas tran vdout1_82ck135 FIND v(dout1_82) AT=680.025n

* CHECK dout1_83 Vdout1_83ck135 = 0.9 time = 680
.meas tran vdout1_83ck135 FIND v(dout1_83) AT=680.025n

* CHECK dout1_84 Vdout1_84ck135 = 0.9 time = 680
.meas tran vdout1_84ck135 FIND v(dout1_84) AT=680.025n

* CHECK dout1_85 Vdout1_85ck135 = 0 time = 680
.meas tran vdout1_85ck135 FIND v(dout1_85) AT=680.025n

* CHECK dout1_86 Vdout1_86ck135 = 0 time = 680
.meas tran vdout1_86ck135 FIND v(dout1_86) AT=680.025n

* CHECK dout1_87 Vdout1_87ck135 = 0.9 time = 680
.meas tran vdout1_87ck135 FIND v(dout1_87) AT=680.025n

* CHECK dout1_88 Vdout1_88ck135 = 0 time = 680
.meas tran vdout1_88ck135 FIND v(dout1_88) AT=680.025n

* CHECK dout1_89 Vdout1_89ck135 = 0 time = 680
.meas tran vdout1_89ck135 FIND v(dout1_89) AT=680.025n

* CHECK dout1_90 Vdout1_90ck135 = 0.9 time = 680
.meas tran vdout1_90ck135 FIND v(dout1_90) AT=680.025n

* CHECK dout1_91 Vdout1_91ck135 = 0.9 time = 680
.meas tran vdout1_91ck135 FIND v(dout1_91) AT=680.025n

* CHECK dout1_92 Vdout1_92ck135 = 0 time = 680
.meas tran vdout1_92ck135 FIND v(dout1_92) AT=680.025n

* CHECK dout1_93 Vdout1_93ck135 = 0 time = 680
.meas tran vdout1_93ck135 FIND v(dout1_93) AT=680.025n

* CHECK dout1_94 Vdout1_94ck135 = 0.9 time = 680
.meas tran vdout1_94ck135 FIND v(dout1_94) AT=680.025n

* CHECK dout1_95 Vdout1_95ck135 = 0.9 time = 680
.meas tran vdout1_95ck135 FIND v(dout1_95) AT=680.025n

* CHECK dout1_96 Vdout1_96ck135 = 0.9 time = 680
.meas tran vdout1_96ck135 FIND v(dout1_96) AT=680.025n

* CHECK dout1_97 Vdout1_97ck135 = 0 time = 680
.meas tran vdout1_97ck135 FIND v(dout1_97) AT=680.025n

* CHECK dout1_98 Vdout1_98ck135 = 0.9 time = 680
.meas tran vdout1_98ck135 FIND v(dout1_98) AT=680.025n

* CHECK dout1_99 Vdout1_99ck135 = 0.9 time = 680
.meas tran vdout1_99ck135 FIND v(dout1_99) AT=680.025n

* CHECK dout1_100 Vdout1_100ck135 = 0 time = 680
.meas tran vdout1_100ck135 FIND v(dout1_100) AT=680.025n

* CHECK dout1_101 Vdout1_101ck135 = 0 time = 680
.meas tran vdout1_101ck135 FIND v(dout1_101) AT=680.025n

* CHECK dout1_102 Vdout1_102ck135 = 0 time = 680
.meas tran vdout1_102ck135 FIND v(dout1_102) AT=680.025n

* CHECK dout1_103 Vdout1_103ck135 = 0 time = 680
.meas tran vdout1_103ck135 FIND v(dout1_103) AT=680.025n

* CHECK dout1_104 Vdout1_104ck135 = 0 time = 680
.meas tran vdout1_104ck135 FIND v(dout1_104) AT=680.025n

* CHECK dout1_105 Vdout1_105ck135 = 0.9 time = 680
.meas tran vdout1_105ck135 FIND v(dout1_105) AT=680.025n

* CHECK dout1_106 Vdout1_106ck135 = 0.9 time = 680
.meas tran vdout1_106ck135 FIND v(dout1_106) AT=680.025n

* CHECK dout1_107 Vdout1_107ck135 = 0.9 time = 680
.meas tran vdout1_107ck135 FIND v(dout1_107) AT=680.025n

* CHECK dout1_108 Vdout1_108ck135 = 0 time = 680
.meas tran vdout1_108ck135 FIND v(dout1_108) AT=680.025n

* CHECK dout1_109 Vdout1_109ck135 = 0.9 time = 680
.meas tran vdout1_109ck135 FIND v(dout1_109) AT=680.025n

* CHECK dout1_110 Vdout1_110ck135 = 0.9 time = 680
.meas tran vdout1_110ck135 FIND v(dout1_110) AT=680.025n

* CHECK dout1_111 Vdout1_111ck135 = 0 time = 680
.meas tran vdout1_111ck135 FIND v(dout1_111) AT=680.025n

* CHECK dout1_112 Vdout1_112ck135 = 0 time = 680
.meas tran vdout1_112ck135 FIND v(dout1_112) AT=680.025n

* CHECK dout1_113 Vdout1_113ck135 = 0.9 time = 680
.meas tran vdout1_113ck135 FIND v(dout1_113) AT=680.025n

* CHECK dout1_114 Vdout1_114ck135 = 0.9 time = 680
.meas tran vdout1_114ck135 FIND v(dout1_114) AT=680.025n

* CHECK dout1_115 Vdout1_115ck135 = 0 time = 680
.meas tran vdout1_115ck135 FIND v(dout1_115) AT=680.025n

* CHECK dout1_116 Vdout1_116ck135 = 0 time = 680
.meas tran vdout1_116ck135 FIND v(dout1_116) AT=680.025n

* CHECK dout1_117 Vdout1_117ck135 = 0 time = 680
.meas tran vdout1_117ck135 FIND v(dout1_117) AT=680.025n

* CHECK dout1_118 Vdout1_118ck135 = 0 time = 680
.meas tran vdout1_118ck135 FIND v(dout1_118) AT=680.025n

* CHECK dout1_119 Vdout1_119ck135 = 0 time = 680
.meas tran vdout1_119ck135 FIND v(dout1_119) AT=680.025n

* CHECK dout1_0 Vdout1_0ck147 = 0 time = 740
.meas tran vdout1_0ck147 FIND v(dout1_0) AT=740.025n

* CHECK dout1_1 Vdout1_1ck147 = 0.9 time = 740
.meas tran vdout1_1ck147 FIND v(dout1_1) AT=740.025n

* CHECK dout1_2 Vdout1_2ck147 = 0 time = 740
.meas tran vdout1_2ck147 FIND v(dout1_2) AT=740.025n

* CHECK dout1_3 Vdout1_3ck147 = 0 time = 740
.meas tran vdout1_3ck147 FIND v(dout1_3) AT=740.025n

* CHECK dout1_4 Vdout1_4ck147 = 0 time = 740
.meas tran vdout1_4ck147 FIND v(dout1_4) AT=740.025n

* CHECK dout1_5 Vdout1_5ck147 = 0.9 time = 740
.meas tran vdout1_5ck147 FIND v(dout1_5) AT=740.025n

* CHECK dout1_6 Vdout1_6ck147 = 0 time = 740
.meas tran vdout1_6ck147 FIND v(dout1_6) AT=740.025n

* CHECK dout1_7 Vdout1_7ck147 = 0.9 time = 740
.meas tran vdout1_7ck147 FIND v(dout1_7) AT=740.025n

* CHECK dout1_8 Vdout1_8ck147 = 0.9 time = 740
.meas tran vdout1_8ck147 FIND v(dout1_8) AT=740.025n

* CHECK dout1_9 Vdout1_9ck147 = 0.9 time = 740
.meas tran vdout1_9ck147 FIND v(dout1_9) AT=740.025n

* CHECK dout1_10 Vdout1_10ck147 = 0 time = 740
.meas tran vdout1_10ck147 FIND v(dout1_10) AT=740.025n

* CHECK dout1_11 Vdout1_11ck147 = 0.9 time = 740
.meas tran vdout1_11ck147 FIND v(dout1_11) AT=740.025n

* CHECK dout1_12 Vdout1_12ck147 = 0.9 time = 740
.meas tran vdout1_12ck147 FIND v(dout1_12) AT=740.025n

* CHECK dout1_13 Vdout1_13ck147 = 0.9 time = 740
.meas tran vdout1_13ck147 FIND v(dout1_13) AT=740.025n

* CHECK dout1_14 Vdout1_14ck147 = 0 time = 740
.meas tran vdout1_14ck147 FIND v(dout1_14) AT=740.025n

* CHECK dout1_15 Vdout1_15ck147 = 0.9 time = 740
.meas tran vdout1_15ck147 FIND v(dout1_15) AT=740.025n

* CHECK dout1_16 Vdout1_16ck147 = 0 time = 740
.meas tran vdout1_16ck147 FIND v(dout1_16) AT=740.025n

* CHECK dout1_17 Vdout1_17ck147 = 0.9 time = 740
.meas tran vdout1_17ck147 FIND v(dout1_17) AT=740.025n

* CHECK dout1_18 Vdout1_18ck147 = 0.9 time = 740
.meas tran vdout1_18ck147 FIND v(dout1_18) AT=740.025n

* CHECK dout1_19 Vdout1_19ck147 = 0.9 time = 740
.meas tran vdout1_19ck147 FIND v(dout1_19) AT=740.025n

* CHECK dout1_20 Vdout1_20ck147 = 0.9 time = 740
.meas tran vdout1_20ck147 FIND v(dout1_20) AT=740.025n

* CHECK dout1_21 Vdout1_21ck147 = 0.9 time = 740
.meas tran vdout1_21ck147 FIND v(dout1_21) AT=740.025n

* CHECK dout1_22 Vdout1_22ck147 = 0.9 time = 740
.meas tran vdout1_22ck147 FIND v(dout1_22) AT=740.025n

* CHECK dout1_23 Vdout1_23ck147 = 0.9 time = 740
.meas tran vdout1_23ck147 FIND v(dout1_23) AT=740.025n

* CHECK dout1_24 Vdout1_24ck147 = 0 time = 740
.meas tran vdout1_24ck147 FIND v(dout1_24) AT=740.025n

* CHECK dout1_25 Vdout1_25ck147 = 0.9 time = 740
.meas tran vdout1_25ck147 FIND v(dout1_25) AT=740.025n

* CHECK dout1_26 Vdout1_26ck147 = 0.9 time = 740
.meas tran vdout1_26ck147 FIND v(dout1_26) AT=740.025n

* CHECK dout1_27 Vdout1_27ck147 = 0 time = 740
.meas tran vdout1_27ck147 FIND v(dout1_27) AT=740.025n

* CHECK dout1_28 Vdout1_28ck147 = 0.9 time = 740
.meas tran vdout1_28ck147 FIND v(dout1_28) AT=740.025n

* CHECK dout1_29 Vdout1_29ck147 = 0.9 time = 740
.meas tran vdout1_29ck147 FIND v(dout1_29) AT=740.025n

* CHECK dout1_30 Vdout1_30ck147 = 0 time = 740
.meas tran vdout1_30ck147 FIND v(dout1_30) AT=740.025n

* CHECK dout1_31 Vdout1_31ck147 = 0 time = 740
.meas tran vdout1_31ck147 FIND v(dout1_31) AT=740.025n

* CHECK dout1_32 Vdout1_32ck147 = 0 time = 740
.meas tran vdout1_32ck147 FIND v(dout1_32) AT=740.025n

* CHECK dout1_33 Vdout1_33ck147 = 0 time = 740
.meas tran vdout1_33ck147 FIND v(dout1_33) AT=740.025n

* CHECK dout1_34 Vdout1_34ck147 = 0.9 time = 740
.meas tran vdout1_34ck147 FIND v(dout1_34) AT=740.025n

* CHECK dout1_35 Vdout1_35ck147 = 0.9 time = 740
.meas tran vdout1_35ck147 FIND v(dout1_35) AT=740.025n

* CHECK dout1_36 Vdout1_36ck147 = 0 time = 740
.meas tran vdout1_36ck147 FIND v(dout1_36) AT=740.025n

* CHECK dout1_37 Vdout1_37ck147 = 0.9 time = 740
.meas tran vdout1_37ck147 FIND v(dout1_37) AT=740.025n

* CHECK dout1_38 Vdout1_38ck147 = 0 time = 740
.meas tran vdout1_38ck147 FIND v(dout1_38) AT=740.025n

* CHECK dout1_39 Vdout1_39ck147 = 0.9 time = 740
.meas tran vdout1_39ck147 FIND v(dout1_39) AT=740.025n

* CHECK dout1_40 Vdout1_40ck147 = 0 time = 740
.meas tran vdout1_40ck147 FIND v(dout1_40) AT=740.025n

* CHECK dout1_41 Vdout1_41ck147 = 0 time = 740
.meas tran vdout1_41ck147 FIND v(dout1_41) AT=740.025n

* CHECK dout1_42 Vdout1_42ck147 = 0.9 time = 740
.meas tran vdout1_42ck147 FIND v(dout1_42) AT=740.025n

* CHECK dout1_43 Vdout1_43ck147 = 0 time = 740
.meas tran vdout1_43ck147 FIND v(dout1_43) AT=740.025n

* CHECK dout1_44 Vdout1_44ck147 = 0.9 time = 740
.meas tran vdout1_44ck147 FIND v(dout1_44) AT=740.025n

* CHECK dout1_45 Vdout1_45ck147 = 0 time = 740
.meas tran vdout1_45ck147 FIND v(dout1_45) AT=740.025n

* CHECK dout1_46 Vdout1_46ck147 = 0 time = 740
.meas tran vdout1_46ck147 FIND v(dout1_46) AT=740.025n

* CHECK dout1_47 Vdout1_47ck147 = 0 time = 740
.meas tran vdout1_47ck147 FIND v(dout1_47) AT=740.025n

* CHECK dout1_48 Vdout1_48ck147 = 0.9 time = 740
.meas tran vdout1_48ck147 FIND v(dout1_48) AT=740.025n

* CHECK dout1_49 Vdout1_49ck147 = 0.9 time = 740
.meas tran vdout1_49ck147 FIND v(dout1_49) AT=740.025n

* CHECK dout1_50 Vdout1_50ck147 = 0.9 time = 740
.meas tran vdout1_50ck147 FIND v(dout1_50) AT=740.025n

* CHECK dout1_51 Vdout1_51ck147 = 0.9 time = 740
.meas tran vdout1_51ck147 FIND v(dout1_51) AT=740.025n

* CHECK dout1_52 Vdout1_52ck147 = 0.9 time = 740
.meas tran vdout1_52ck147 FIND v(dout1_52) AT=740.025n

* CHECK dout1_53 Vdout1_53ck147 = 0 time = 740
.meas tran vdout1_53ck147 FIND v(dout1_53) AT=740.025n

* CHECK dout1_54 Vdout1_54ck147 = 0.9 time = 740
.meas tran vdout1_54ck147 FIND v(dout1_54) AT=740.025n

* CHECK dout1_55 Vdout1_55ck147 = 0.9 time = 740
.meas tran vdout1_55ck147 FIND v(dout1_55) AT=740.025n

* CHECK dout1_56 Vdout1_56ck147 = 0 time = 740
.meas tran vdout1_56ck147 FIND v(dout1_56) AT=740.025n

* CHECK dout1_57 Vdout1_57ck147 = 0.9 time = 740
.meas tran vdout1_57ck147 FIND v(dout1_57) AT=740.025n

* CHECK dout1_58 Vdout1_58ck147 = 0.9 time = 740
.meas tran vdout1_58ck147 FIND v(dout1_58) AT=740.025n

* CHECK dout1_59 Vdout1_59ck147 = 0.9 time = 740
.meas tran vdout1_59ck147 FIND v(dout1_59) AT=740.025n

* CHECK dout1_60 Vdout1_60ck147 = 0.9 time = 740
.meas tran vdout1_60ck147 FIND v(dout1_60) AT=740.025n

* CHECK dout1_61 Vdout1_61ck147 = 0 time = 740
.meas tran vdout1_61ck147 FIND v(dout1_61) AT=740.025n

* CHECK dout1_62 Vdout1_62ck147 = 0 time = 740
.meas tran vdout1_62ck147 FIND v(dout1_62) AT=740.025n

* CHECK dout1_63 Vdout1_63ck147 = 0 time = 740
.meas tran vdout1_63ck147 FIND v(dout1_63) AT=740.025n

* CHECK dout1_64 Vdout1_64ck147 = 0 time = 740
.meas tran vdout1_64ck147 FIND v(dout1_64) AT=740.025n

* CHECK dout1_65 Vdout1_65ck147 = 0.9 time = 740
.meas tran vdout1_65ck147 FIND v(dout1_65) AT=740.025n

* CHECK dout1_66 Vdout1_66ck147 = 0.9 time = 740
.meas tran vdout1_66ck147 FIND v(dout1_66) AT=740.025n

* CHECK dout1_67 Vdout1_67ck147 = 0.9 time = 740
.meas tran vdout1_67ck147 FIND v(dout1_67) AT=740.025n

* CHECK dout1_68 Vdout1_68ck147 = 0.9 time = 740
.meas tran vdout1_68ck147 FIND v(dout1_68) AT=740.025n

* CHECK dout1_69 Vdout1_69ck147 = 0.9 time = 740
.meas tran vdout1_69ck147 FIND v(dout1_69) AT=740.025n

* CHECK dout1_70 Vdout1_70ck147 = 0 time = 740
.meas tran vdout1_70ck147 FIND v(dout1_70) AT=740.025n

* CHECK dout1_71 Vdout1_71ck147 = 0 time = 740
.meas tran vdout1_71ck147 FIND v(dout1_71) AT=740.025n

* CHECK dout1_72 Vdout1_72ck147 = 0.9 time = 740
.meas tran vdout1_72ck147 FIND v(dout1_72) AT=740.025n

* CHECK dout1_73 Vdout1_73ck147 = 0.9 time = 740
.meas tran vdout1_73ck147 FIND v(dout1_73) AT=740.025n

* CHECK dout1_74 Vdout1_74ck147 = 0 time = 740
.meas tran vdout1_74ck147 FIND v(dout1_74) AT=740.025n

* CHECK dout1_75 Vdout1_75ck147 = 0.9 time = 740
.meas tran vdout1_75ck147 FIND v(dout1_75) AT=740.025n

* CHECK dout1_76 Vdout1_76ck147 = 0.9 time = 740
.meas tran vdout1_76ck147 FIND v(dout1_76) AT=740.025n

* CHECK dout1_77 Vdout1_77ck147 = 0.9 time = 740
.meas tran vdout1_77ck147 FIND v(dout1_77) AT=740.025n

* CHECK dout1_78 Vdout1_78ck147 = 0 time = 740
.meas tran vdout1_78ck147 FIND v(dout1_78) AT=740.025n

* CHECK dout1_79 Vdout1_79ck147 = 0.9 time = 740
.meas tran vdout1_79ck147 FIND v(dout1_79) AT=740.025n

* CHECK dout1_80 Vdout1_80ck147 = 0 time = 740
.meas tran vdout1_80ck147 FIND v(dout1_80) AT=740.025n

* CHECK dout1_81 Vdout1_81ck147 = 0 time = 740
.meas tran vdout1_81ck147 FIND v(dout1_81) AT=740.025n

* CHECK dout1_82 Vdout1_82ck147 = 0 time = 740
.meas tran vdout1_82ck147 FIND v(dout1_82) AT=740.025n

* CHECK dout1_83 Vdout1_83ck147 = 0 time = 740
.meas tran vdout1_83ck147 FIND v(dout1_83) AT=740.025n

* CHECK dout1_84 Vdout1_84ck147 = 0 time = 740
.meas tran vdout1_84ck147 FIND v(dout1_84) AT=740.025n

* CHECK dout1_85 Vdout1_85ck147 = 0 time = 740
.meas tran vdout1_85ck147 FIND v(dout1_85) AT=740.025n

* CHECK dout1_86 Vdout1_86ck147 = 0.9 time = 740
.meas tran vdout1_86ck147 FIND v(dout1_86) AT=740.025n

* CHECK dout1_87 Vdout1_87ck147 = 0.9 time = 740
.meas tran vdout1_87ck147 FIND v(dout1_87) AT=740.025n

* CHECK dout1_88 Vdout1_88ck147 = 0 time = 740
.meas tran vdout1_88ck147 FIND v(dout1_88) AT=740.025n

* CHECK dout1_89 Vdout1_89ck147 = 0.9 time = 740
.meas tran vdout1_89ck147 FIND v(dout1_89) AT=740.025n

* CHECK dout1_90 Vdout1_90ck147 = 0 time = 740
.meas tran vdout1_90ck147 FIND v(dout1_90) AT=740.025n

* CHECK dout1_91 Vdout1_91ck147 = 0.9 time = 740
.meas tran vdout1_91ck147 FIND v(dout1_91) AT=740.025n

* CHECK dout1_92 Vdout1_92ck147 = 0 time = 740
.meas tran vdout1_92ck147 FIND v(dout1_92) AT=740.025n

* CHECK dout1_93 Vdout1_93ck147 = 0.9 time = 740
.meas tran vdout1_93ck147 FIND v(dout1_93) AT=740.025n

* CHECK dout1_94 Vdout1_94ck147 = 0 time = 740
.meas tran vdout1_94ck147 FIND v(dout1_94) AT=740.025n

* CHECK dout1_95 Vdout1_95ck147 = 0 time = 740
.meas tran vdout1_95ck147 FIND v(dout1_95) AT=740.025n

* CHECK dout1_96 Vdout1_96ck147 = 0 time = 740
.meas tran vdout1_96ck147 FIND v(dout1_96) AT=740.025n

* CHECK dout1_97 Vdout1_97ck147 = 0.9 time = 740
.meas tran vdout1_97ck147 FIND v(dout1_97) AT=740.025n

* CHECK dout1_98 Vdout1_98ck147 = 0.9 time = 740
.meas tran vdout1_98ck147 FIND v(dout1_98) AT=740.025n

* CHECK dout1_99 Vdout1_99ck147 = 0 time = 740
.meas tran vdout1_99ck147 FIND v(dout1_99) AT=740.025n

* CHECK dout1_100 Vdout1_100ck147 = 0.9 time = 740
.meas tran vdout1_100ck147 FIND v(dout1_100) AT=740.025n

* CHECK dout1_101 Vdout1_101ck147 = 0.9 time = 740
.meas tran vdout1_101ck147 FIND v(dout1_101) AT=740.025n

* CHECK dout1_102 Vdout1_102ck147 = 0 time = 740
.meas tran vdout1_102ck147 FIND v(dout1_102) AT=740.025n

* CHECK dout1_103 Vdout1_103ck147 = 0 time = 740
.meas tran vdout1_103ck147 FIND v(dout1_103) AT=740.025n

* CHECK dout1_104 Vdout1_104ck147 = 0 time = 740
.meas tran vdout1_104ck147 FIND v(dout1_104) AT=740.025n

* CHECK dout1_105 Vdout1_105ck147 = 0.9 time = 740
.meas tran vdout1_105ck147 FIND v(dout1_105) AT=740.025n

* CHECK dout1_106 Vdout1_106ck147 = 0 time = 740
.meas tran vdout1_106ck147 FIND v(dout1_106) AT=740.025n

* CHECK dout1_107 Vdout1_107ck147 = 0 time = 740
.meas tran vdout1_107ck147 FIND v(dout1_107) AT=740.025n

* CHECK dout1_108 Vdout1_108ck147 = 0.9 time = 740
.meas tran vdout1_108ck147 FIND v(dout1_108) AT=740.025n

* CHECK dout1_109 Vdout1_109ck147 = 0 time = 740
.meas tran vdout1_109ck147 FIND v(dout1_109) AT=740.025n

* CHECK dout1_110 Vdout1_110ck147 = 0.9 time = 740
.meas tran vdout1_110ck147 FIND v(dout1_110) AT=740.025n

* CHECK dout1_111 Vdout1_111ck147 = 0 time = 740
.meas tran vdout1_111ck147 FIND v(dout1_111) AT=740.025n

* CHECK dout1_112 Vdout1_112ck147 = 0 time = 740
.meas tran vdout1_112ck147 FIND v(dout1_112) AT=740.025n

* CHECK dout1_113 Vdout1_113ck147 = 0.9 time = 740
.meas tran vdout1_113ck147 FIND v(dout1_113) AT=740.025n

* CHECK dout1_114 Vdout1_114ck147 = 0.9 time = 740
.meas tran vdout1_114ck147 FIND v(dout1_114) AT=740.025n

* CHECK dout1_115 Vdout1_115ck147 = 0.9 time = 740
.meas tran vdout1_115ck147 FIND v(dout1_115) AT=740.025n

* CHECK dout1_116 Vdout1_116ck147 = 0.9 time = 740
.meas tran vdout1_116ck147 FIND v(dout1_116) AT=740.025n

* CHECK dout1_117 Vdout1_117ck147 = 0 time = 740
.meas tran vdout1_117ck147 FIND v(dout1_117) AT=740.025n

* CHECK dout1_118 Vdout1_118ck147 = 0.9 time = 740
.meas tran vdout1_118ck147 FIND v(dout1_118) AT=740.025n

* CHECK dout1_119 Vdout1_119ck147 = 0 time = 740
.meas tran vdout1_119ck147 FIND v(dout1_119) AT=740.025n

* CHECK dout1_0 Vdout1_0ck153 = 0.9 time = 770
.meas tran vdout1_0ck153 FIND v(dout1_0) AT=770.025n

* CHECK dout1_1 Vdout1_1ck153 = 0.9 time = 770
.meas tran vdout1_1ck153 FIND v(dout1_1) AT=770.025n

* CHECK dout1_2 Vdout1_2ck153 = 0 time = 770
.meas tran vdout1_2ck153 FIND v(dout1_2) AT=770.025n

* CHECK dout1_3 Vdout1_3ck153 = 0 time = 770
.meas tran vdout1_3ck153 FIND v(dout1_3) AT=770.025n

* CHECK dout1_4 Vdout1_4ck153 = 0 time = 770
.meas tran vdout1_4ck153 FIND v(dout1_4) AT=770.025n

* CHECK dout1_5 Vdout1_5ck153 = 0.9 time = 770
.meas tran vdout1_5ck153 FIND v(dout1_5) AT=770.025n

* CHECK dout1_6 Vdout1_6ck153 = 0 time = 770
.meas tran vdout1_6ck153 FIND v(dout1_6) AT=770.025n

* CHECK dout1_7 Vdout1_7ck153 = 0.9 time = 770
.meas tran vdout1_7ck153 FIND v(dout1_7) AT=770.025n

* CHECK dout1_8 Vdout1_8ck153 = 0.9 time = 770
.meas tran vdout1_8ck153 FIND v(dout1_8) AT=770.025n

* CHECK dout1_9 Vdout1_9ck153 = 0.9 time = 770
.meas tran vdout1_9ck153 FIND v(dout1_9) AT=770.025n

* CHECK dout1_10 Vdout1_10ck153 = 0.9 time = 770
.meas tran vdout1_10ck153 FIND v(dout1_10) AT=770.025n

* CHECK dout1_11 Vdout1_11ck153 = 0.9 time = 770
.meas tran vdout1_11ck153 FIND v(dout1_11) AT=770.025n

* CHECK dout1_12 Vdout1_12ck153 = 0 time = 770
.meas tran vdout1_12ck153 FIND v(dout1_12) AT=770.025n

* CHECK dout1_13 Vdout1_13ck153 = 0 time = 770
.meas tran vdout1_13ck153 FIND v(dout1_13) AT=770.025n

* CHECK dout1_14 Vdout1_14ck153 = 0 time = 770
.meas tran vdout1_14ck153 FIND v(dout1_14) AT=770.025n

* CHECK dout1_15 Vdout1_15ck153 = 0 time = 770
.meas tran vdout1_15ck153 FIND v(dout1_15) AT=770.025n

* CHECK dout1_16 Vdout1_16ck153 = 0.9 time = 770
.meas tran vdout1_16ck153 FIND v(dout1_16) AT=770.025n

* CHECK dout1_17 Vdout1_17ck153 = 0 time = 770
.meas tran vdout1_17ck153 FIND v(dout1_17) AT=770.025n

* CHECK dout1_18 Vdout1_18ck153 = 0.9 time = 770
.meas tran vdout1_18ck153 FIND v(dout1_18) AT=770.025n

* CHECK dout1_19 Vdout1_19ck153 = 0.9 time = 770
.meas tran vdout1_19ck153 FIND v(dout1_19) AT=770.025n

* CHECK dout1_20 Vdout1_20ck153 = 0.9 time = 770
.meas tran vdout1_20ck153 FIND v(dout1_20) AT=770.025n

* CHECK dout1_21 Vdout1_21ck153 = 0 time = 770
.meas tran vdout1_21ck153 FIND v(dout1_21) AT=770.025n

* CHECK dout1_22 Vdout1_22ck153 = 0 time = 770
.meas tran vdout1_22ck153 FIND v(dout1_22) AT=770.025n

* CHECK dout1_23 Vdout1_23ck153 = 0.9 time = 770
.meas tran vdout1_23ck153 FIND v(dout1_23) AT=770.025n

* CHECK dout1_24 Vdout1_24ck153 = 0 time = 770
.meas tran vdout1_24ck153 FIND v(dout1_24) AT=770.025n

* CHECK dout1_25 Vdout1_25ck153 = 0 time = 770
.meas tran vdout1_25ck153 FIND v(dout1_25) AT=770.025n

* CHECK dout1_26 Vdout1_26ck153 = 0 time = 770
.meas tran vdout1_26ck153 FIND v(dout1_26) AT=770.025n

* CHECK dout1_27 Vdout1_27ck153 = 0 time = 770
.meas tran vdout1_27ck153 FIND v(dout1_27) AT=770.025n

* CHECK dout1_28 Vdout1_28ck153 = 0.9 time = 770
.meas tran vdout1_28ck153 FIND v(dout1_28) AT=770.025n

* CHECK dout1_29 Vdout1_29ck153 = 0.9 time = 770
.meas tran vdout1_29ck153 FIND v(dout1_29) AT=770.025n

* CHECK dout1_30 Vdout1_30ck153 = 0 time = 770
.meas tran vdout1_30ck153 FIND v(dout1_30) AT=770.025n

* CHECK dout1_31 Vdout1_31ck153 = 0.9 time = 770
.meas tran vdout1_31ck153 FIND v(dout1_31) AT=770.025n

* CHECK dout1_32 Vdout1_32ck153 = 0 time = 770
.meas tran vdout1_32ck153 FIND v(dout1_32) AT=770.025n

* CHECK dout1_33 Vdout1_33ck153 = 0.9 time = 770
.meas tran vdout1_33ck153 FIND v(dout1_33) AT=770.025n

* CHECK dout1_34 Vdout1_34ck153 = 0 time = 770
.meas tran vdout1_34ck153 FIND v(dout1_34) AT=770.025n

* CHECK dout1_35 Vdout1_35ck153 = 0.9 time = 770
.meas tran vdout1_35ck153 FIND v(dout1_35) AT=770.025n

* CHECK dout1_36 Vdout1_36ck153 = 0.9 time = 770
.meas tran vdout1_36ck153 FIND v(dout1_36) AT=770.025n

* CHECK dout1_37 Vdout1_37ck153 = 0 time = 770
.meas tran vdout1_37ck153 FIND v(dout1_37) AT=770.025n

* CHECK dout1_38 Vdout1_38ck153 = 0 time = 770
.meas tran vdout1_38ck153 FIND v(dout1_38) AT=770.025n

* CHECK dout1_39 Vdout1_39ck153 = 0 time = 770
.meas tran vdout1_39ck153 FIND v(dout1_39) AT=770.025n

* CHECK dout1_40 Vdout1_40ck153 = 0 time = 770
.meas tran vdout1_40ck153 FIND v(dout1_40) AT=770.025n

* CHECK dout1_41 Vdout1_41ck153 = 0.9 time = 770
.meas tran vdout1_41ck153 FIND v(dout1_41) AT=770.025n

* CHECK dout1_42 Vdout1_42ck153 = 0 time = 770
.meas tran vdout1_42ck153 FIND v(dout1_42) AT=770.025n

* CHECK dout1_43 Vdout1_43ck153 = 0 time = 770
.meas tran vdout1_43ck153 FIND v(dout1_43) AT=770.025n

* CHECK dout1_44 Vdout1_44ck153 = 0 time = 770
.meas tran vdout1_44ck153 FIND v(dout1_44) AT=770.025n

* CHECK dout1_45 Vdout1_45ck153 = 0.9 time = 770
.meas tran vdout1_45ck153 FIND v(dout1_45) AT=770.025n

* CHECK dout1_46 Vdout1_46ck153 = 0.9 time = 770
.meas tran vdout1_46ck153 FIND v(dout1_46) AT=770.025n

* CHECK dout1_47 Vdout1_47ck153 = 0 time = 770
.meas tran vdout1_47ck153 FIND v(dout1_47) AT=770.025n

* CHECK dout1_48 Vdout1_48ck153 = 0.9 time = 770
.meas tran vdout1_48ck153 FIND v(dout1_48) AT=770.025n

* CHECK dout1_49 Vdout1_49ck153 = 0 time = 770
.meas tran vdout1_49ck153 FIND v(dout1_49) AT=770.025n

* CHECK dout1_50 Vdout1_50ck153 = 0.9 time = 770
.meas tran vdout1_50ck153 FIND v(dout1_50) AT=770.025n

* CHECK dout1_51 Vdout1_51ck153 = 0.9 time = 770
.meas tran vdout1_51ck153 FIND v(dout1_51) AT=770.025n

* CHECK dout1_52 Vdout1_52ck153 = 0.9 time = 770
.meas tran vdout1_52ck153 FIND v(dout1_52) AT=770.025n

* CHECK dout1_53 Vdout1_53ck153 = 0 time = 770
.meas tran vdout1_53ck153 FIND v(dout1_53) AT=770.025n

* CHECK dout1_54 Vdout1_54ck153 = 0.9 time = 770
.meas tran vdout1_54ck153 FIND v(dout1_54) AT=770.025n

* CHECK dout1_55 Vdout1_55ck153 = 0 time = 770
.meas tran vdout1_55ck153 FIND v(dout1_55) AT=770.025n

* CHECK dout1_56 Vdout1_56ck153 = 0 time = 770
.meas tran vdout1_56ck153 FIND v(dout1_56) AT=770.025n

* CHECK dout1_57 Vdout1_57ck153 = 0.9 time = 770
.meas tran vdout1_57ck153 FIND v(dout1_57) AT=770.025n

* CHECK dout1_58 Vdout1_58ck153 = 0 time = 770
.meas tran vdout1_58ck153 FIND v(dout1_58) AT=770.025n

* CHECK dout1_59 Vdout1_59ck153 = 0 time = 770
.meas tran vdout1_59ck153 FIND v(dout1_59) AT=770.025n

* CHECK dout1_60 Vdout1_60ck153 = 0.9 time = 770
.meas tran vdout1_60ck153 FIND v(dout1_60) AT=770.025n

* CHECK dout1_61 Vdout1_61ck153 = 0 time = 770
.meas tran vdout1_61ck153 FIND v(dout1_61) AT=770.025n

* CHECK dout1_62 Vdout1_62ck153 = 0 time = 770
.meas tran vdout1_62ck153 FIND v(dout1_62) AT=770.025n

* CHECK dout1_63 Vdout1_63ck153 = 0 time = 770
.meas tran vdout1_63ck153 FIND v(dout1_63) AT=770.025n

* CHECK dout1_64 Vdout1_64ck153 = 0 time = 770
.meas tran vdout1_64ck153 FIND v(dout1_64) AT=770.025n

* CHECK dout1_65 Vdout1_65ck153 = 0 time = 770
.meas tran vdout1_65ck153 FIND v(dout1_65) AT=770.025n

* CHECK dout1_66 Vdout1_66ck153 = 0 time = 770
.meas tran vdout1_66ck153 FIND v(dout1_66) AT=770.025n

* CHECK dout1_67 Vdout1_67ck153 = 0 time = 770
.meas tran vdout1_67ck153 FIND v(dout1_67) AT=770.025n

* CHECK dout1_68 Vdout1_68ck153 = 0.9 time = 770
.meas tran vdout1_68ck153 FIND v(dout1_68) AT=770.025n

* CHECK dout1_69 Vdout1_69ck153 = 0.9 time = 770
.meas tran vdout1_69ck153 FIND v(dout1_69) AT=770.025n

* CHECK dout1_70 Vdout1_70ck153 = 0 time = 770
.meas tran vdout1_70ck153 FIND v(dout1_70) AT=770.025n

* CHECK dout1_71 Vdout1_71ck153 = 0 time = 770
.meas tran vdout1_71ck153 FIND v(dout1_71) AT=770.025n

* CHECK dout1_72 Vdout1_72ck153 = 0 time = 770
.meas tran vdout1_72ck153 FIND v(dout1_72) AT=770.025n

* CHECK dout1_73 Vdout1_73ck153 = 0 time = 770
.meas tran vdout1_73ck153 FIND v(dout1_73) AT=770.025n

* CHECK dout1_74 Vdout1_74ck153 = 0 time = 770
.meas tran vdout1_74ck153 FIND v(dout1_74) AT=770.025n

* CHECK dout1_75 Vdout1_75ck153 = 0 time = 770
.meas tran vdout1_75ck153 FIND v(dout1_75) AT=770.025n

* CHECK dout1_76 Vdout1_76ck153 = 0 time = 770
.meas tran vdout1_76ck153 FIND v(dout1_76) AT=770.025n

* CHECK dout1_77 Vdout1_77ck153 = 0.9 time = 770
.meas tran vdout1_77ck153 FIND v(dout1_77) AT=770.025n

* CHECK dout1_78 Vdout1_78ck153 = 0 time = 770
.meas tran vdout1_78ck153 FIND v(dout1_78) AT=770.025n

* CHECK dout1_79 Vdout1_79ck153 = 0 time = 770
.meas tran vdout1_79ck153 FIND v(dout1_79) AT=770.025n

* CHECK dout1_80 Vdout1_80ck153 = 0 time = 770
.meas tran vdout1_80ck153 FIND v(dout1_80) AT=770.025n

* CHECK dout1_81 Vdout1_81ck153 = 0 time = 770
.meas tran vdout1_81ck153 FIND v(dout1_81) AT=770.025n

* CHECK dout1_82 Vdout1_82ck153 = 0.9 time = 770
.meas tran vdout1_82ck153 FIND v(dout1_82) AT=770.025n

* CHECK dout1_83 Vdout1_83ck153 = 0 time = 770
.meas tran vdout1_83ck153 FIND v(dout1_83) AT=770.025n

* CHECK dout1_84 Vdout1_84ck153 = 0.9 time = 770
.meas tran vdout1_84ck153 FIND v(dout1_84) AT=770.025n

* CHECK dout1_85 Vdout1_85ck153 = 0.9 time = 770
.meas tran vdout1_85ck153 FIND v(dout1_85) AT=770.025n

* CHECK dout1_86 Vdout1_86ck153 = 0.9 time = 770
.meas tran vdout1_86ck153 FIND v(dout1_86) AT=770.025n

* CHECK dout1_87 Vdout1_87ck153 = 0 time = 770
.meas tran vdout1_87ck153 FIND v(dout1_87) AT=770.025n

* CHECK dout1_88 Vdout1_88ck153 = 0.9 time = 770
.meas tran vdout1_88ck153 FIND v(dout1_88) AT=770.025n

* CHECK dout1_89 Vdout1_89ck153 = 0.9 time = 770
.meas tran vdout1_89ck153 FIND v(dout1_89) AT=770.025n

* CHECK dout1_90 Vdout1_90ck153 = 0 time = 770
.meas tran vdout1_90ck153 FIND v(dout1_90) AT=770.025n

* CHECK dout1_91 Vdout1_91ck153 = 0 time = 770
.meas tran vdout1_91ck153 FIND v(dout1_91) AT=770.025n

* CHECK dout1_92 Vdout1_92ck153 = 0 time = 770
.meas tran vdout1_92ck153 FIND v(dout1_92) AT=770.025n

* CHECK dout1_93 Vdout1_93ck153 = 0 time = 770
.meas tran vdout1_93ck153 FIND v(dout1_93) AT=770.025n

* CHECK dout1_94 Vdout1_94ck153 = 0.9 time = 770
.meas tran vdout1_94ck153 FIND v(dout1_94) AT=770.025n

* CHECK dout1_95 Vdout1_95ck153 = 0.9 time = 770
.meas tran vdout1_95ck153 FIND v(dout1_95) AT=770.025n

* CHECK dout1_96 Vdout1_96ck153 = 0 time = 770
.meas tran vdout1_96ck153 FIND v(dout1_96) AT=770.025n

* CHECK dout1_97 Vdout1_97ck153 = 0.9 time = 770
.meas tran vdout1_97ck153 FIND v(dout1_97) AT=770.025n

* CHECK dout1_98 Vdout1_98ck153 = 0.9 time = 770
.meas tran vdout1_98ck153 FIND v(dout1_98) AT=770.025n

* CHECK dout1_99 Vdout1_99ck153 = 0 time = 770
.meas tran vdout1_99ck153 FIND v(dout1_99) AT=770.025n

* CHECK dout1_100 Vdout1_100ck153 = 0 time = 770
.meas tran vdout1_100ck153 FIND v(dout1_100) AT=770.025n

* CHECK dout1_101 Vdout1_101ck153 = 0 time = 770
.meas tran vdout1_101ck153 FIND v(dout1_101) AT=770.025n

* CHECK dout1_102 Vdout1_102ck153 = 0.9 time = 770
.meas tran vdout1_102ck153 FIND v(dout1_102) AT=770.025n

* CHECK dout1_103 Vdout1_103ck153 = 0.9 time = 770
.meas tran vdout1_103ck153 FIND v(dout1_103) AT=770.025n

* CHECK dout1_104 Vdout1_104ck153 = 0 time = 770
.meas tran vdout1_104ck153 FIND v(dout1_104) AT=770.025n

* CHECK dout1_105 Vdout1_105ck153 = 0.9 time = 770
.meas tran vdout1_105ck153 FIND v(dout1_105) AT=770.025n

* CHECK dout1_106 Vdout1_106ck153 = 0.9 time = 770
.meas tran vdout1_106ck153 FIND v(dout1_106) AT=770.025n

* CHECK dout1_107 Vdout1_107ck153 = 0 time = 770
.meas tran vdout1_107ck153 FIND v(dout1_107) AT=770.025n

* CHECK dout1_108 Vdout1_108ck153 = 0.9 time = 770
.meas tran vdout1_108ck153 FIND v(dout1_108) AT=770.025n

* CHECK dout1_109 Vdout1_109ck153 = 0 time = 770
.meas tran vdout1_109ck153 FIND v(dout1_109) AT=770.025n

* CHECK dout1_110 Vdout1_110ck153 = 0 time = 770
.meas tran vdout1_110ck153 FIND v(dout1_110) AT=770.025n

* CHECK dout1_111 Vdout1_111ck153 = 0 time = 770
.meas tran vdout1_111ck153 FIND v(dout1_111) AT=770.025n

* CHECK dout1_112 Vdout1_112ck153 = 0.9 time = 770
.meas tran vdout1_112ck153 FIND v(dout1_112) AT=770.025n

* CHECK dout1_113 Vdout1_113ck153 = 0 time = 770
.meas tran vdout1_113ck153 FIND v(dout1_113) AT=770.025n

* CHECK dout1_114 Vdout1_114ck153 = 0.9 time = 770
.meas tran vdout1_114ck153 FIND v(dout1_114) AT=770.025n

* CHECK dout1_115 Vdout1_115ck153 = 0 time = 770
.meas tran vdout1_115ck153 FIND v(dout1_115) AT=770.025n

* CHECK dout1_116 Vdout1_116ck153 = 0 time = 770
.meas tran vdout1_116ck153 FIND v(dout1_116) AT=770.025n

* CHECK dout1_117 Vdout1_117ck153 = 0 time = 770
.meas tran vdout1_117ck153 FIND v(dout1_117) AT=770.025n

* CHECK dout1_118 Vdout1_118ck153 = 0.9 time = 770
.meas tran vdout1_118ck153 FIND v(dout1_118) AT=770.025n

* CHECK dout1_119 Vdout1_119ck153 = 0.9 time = 770
.meas tran vdout1_119ck153 FIND v(dout1_119) AT=770.025n

* CHECK dout1_0 Vdout1_0ck156 = 0.9 time = 785
.meas tran vdout1_0ck156 FIND v(dout1_0) AT=785.025n

* CHECK dout1_1 Vdout1_1ck156 = 0.9 time = 785
.meas tran vdout1_1ck156 FIND v(dout1_1) AT=785.025n

* CHECK dout1_2 Vdout1_2ck156 = 0 time = 785
.meas tran vdout1_2ck156 FIND v(dout1_2) AT=785.025n

* CHECK dout1_3 Vdout1_3ck156 = 0 time = 785
.meas tran vdout1_3ck156 FIND v(dout1_3) AT=785.025n

* CHECK dout1_4 Vdout1_4ck156 = 0 time = 785
.meas tran vdout1_4ck156 FIND v(dout1_4) AT=785.025n

* CHECK dout1_5 Vdout1_5ck156 = 0.9 time = 785
.meas tran vdout1_5ck156 FIND v(dout1_5) AT=785.025n

* CHECK dout1_6 Vdout1_6ck156 = 0 time = 785
.meas tran vdout1_6ck156 FIND v(dout1_6) AT=785.025n

* CHECK dout1_7 Vdout1_7ck156 = 0.9 time = 785
.meas tran vdout1_7ck156 FIND v(dout1_7) AT=785.025n

* CHECK dout1_8 Vdout1_8ck156 = 0.9 time = 785
.meas tran vdout1_8ck156 FIND v(dout1_8) AT=785.025n

* CHECK dout1_9 Vdout1_9ck156 = 0.9 time = 785
.meas tran vdout1_9ck156 FIND v(dout1_9) AT=785.025n

* CHECK dout1_10 Vdout1_10ck156 = 0.9 time = 785
.meas tran vdout1_10ck156 FIND v(dout1_10) AT=785.025n

* CHECK dout1_11 Vdout1_11ck156 = 0.9 time = 785
.meas tran vdout1_11ck156 FIND v(dout1_11) AT=785.025n

* CHECK dout1_12 Vdout1_12ck156 = 0 time = 785
.meas tran vdout1_12ck156 FIND v(dout1_12) AT=785.025n

* CHECK dout1_13 Vdout1_13ck156 = 0 time = 785
.meas tran vdout1_13ck156 FIND v(dout1_13) AT=785.025n

* CHECK dout1_14 Vdout1_14ck156 = 0 time = 785
.meas tran vdout1_14ck156 FIND v(dout1_14) AT=785.025n

* CHECK dout1_15 Vdout1_15ck156 = 0 time = 785
.meas tran vdout1_15ck156 FIND v(dout1_15) AT=785.025n

* CHECK dout1_16 Vdout1_16ck156 = 0.9 time = 785
.meas tran vdout1_16ck156 FIND v(dout1_16) AT=785.025n

* CHECK dout1_17 Vdout1_17ck156 = 0 time = 785
.meas tran vdout1_17ck156 FIND v(dout1_17) AT=785.025n

* CHECK dout1_18 Vdout1_18ck156 = 0.9 time = 785
.meas tran vdout1_18ck156 FIND v(dout1_18) AT=785.025n

* CHECK dout1_19 Vdout1_19ck156 = 0.9 time = 785
.meas tran vdout1_19ck156 FIND v(dout1_19) AT=785.025n

* CHECK dout1_20 Vdout1_20ck156 = 0.9 time = 785
.meas tran vdout1_20ck156 FIND v(dout1_20) AT=785.025n

* CHECK dout1_21 Vdout1_21ck156 = 0 time = 785
.meas tran vdout1_21ck156 FIND v(dout1_21) AT=785.025n

* CHECK dout1_22 Vdout1_22ck156 = 0 time = 785
.meas tran vdout1_22ck156 FIND v(dout1_22) AT=785.025n

* CHECK dout1_23 Vdout1_23ck156 = 0.9 time = 785
.meas tran vdout1_23ck156 FIND v(dout1_23) AT=785.025n

* CHECK dout1_24 Vdout1_24ck156 = 0 time = 785
.meas tran vdout1_24ck156 FIND v(dout1_24) AT=785.025n

* CHECK dout1_25 Vdout1_25ck156 = 0 time = 785
.meas tran vdout1_25ck156 FIND v(dout1_25) AT=785.025n

* CHECK dout1_26 Vdout1_26ck156 = 0 time = 785
.meas tran vdout1_26ck156 FIND v(dout1_26) AT=785.025n

* CHECK dout1_27 Vdout1_27ck156 = 0 time = 785
.meas tran vdout1_27ck156 FIND v(dout1_27) AT=785.025n

* CHECK dout1_28 Vdout1_28ck156 = 0.9 time = 785
.meas tran vdout1_28ck156 FIND v(dout1_28) AT=785.025n

* CHECK dout1_29 Vdout1_29ck156 = 0.9 time = 785
.meas tran vdout1_29ck156 FIND v(dout1_29) AT=785.025n

* CHECK dout1_30 Vdout1_30ck156 = 0 time = 785
.meas tran vdout1_30ck156 FIND v(dout1_30) AT=785.025n

* CHECK dout1_31 Vdout1_31ck156 = 0.9 time = 785
.meas tran vdout1_31ck156 FIND v(dout1_31) AT=785.025n

* CHECK dout1_32 Vdout1_32ck156 = 0 time = 785
.meas tran vdout1_32ck156 FIND v(dout1_32) AT=785.025n

* CHECK dout1_33 Vdout1_33ck156 = 0.9 time = 785
.meas tran vdout1_33ck156 FIND v(dout1_33) AT=785.025n

* CHECK dout1_34 Vdout1_34ck156 = 0 time = 785
.meas tran vdout1_34ck156 FIND v(dout1_34) AT=785.025n

* CHECK dout1_35 Vdout1_35ck156 = 0.9 time = 785
.meas tran vdout1_35ck156 FIND v(dout1_35) AT=785.025n

* CHECK dout1_36 Vdout1_36ck156 = 0.9 time = 785
.meas tran vdout1_36ck156 FIND v(dout1_36) AT=785.025n

* CHECK dout1_37 Vdout1_37ck156 = 0 time = 785
.meas tran vdout1_37ck156 FIND v(dout1_37) AT=785.025n

* CHECK dout1_38 Vdout1_38ck156 = 0 time = 785
.meas tran vdout1_38ck156 FIND v(dout1_38) AT=785.025n

* CHECK dout1_39 Vdout1_39ck156 = 0 time = 785
.meas tran vdout1_39ck156 FIND v(dout1_39) AT=785.025n

* CHECK dout1_40 Vdout1_40ck156 = 0 time = 785
.meas tran vdout1_40ck156 FIND v(dout1_40) AT=785.025n

* CHECK dout1_41 Vdout1_41ck156 = 0.9 time = 785
.meas tran vdout1_41ck156 FIND v(dout1_41) AT=785.025n

* CHECK dout1_42 Vdout1_42ck156 = 0 time = 785
.meas tran vdout1_42ck156 FIND v(dout1_42) AT=785.025n

* CHECK dout1_43 Vdout1_43ck156 = 0 time = 785
.meas tran vdout1_43ck156 FIND v(dout1_43) AT=785.025n

* CHECK dout1_44 Vdout1_44ck156 = 0 time = 785
.meas tran vdout1_44ck156 FIND v(dout1_44) AT=785.025n

* CHECK dout1_45 Vdout1_45ck156 = 0.9 time = 785
.meas tran vdout1_45ck156 FIND v(dout1_45) AT=785.025n

* CHECK dout1_46 Vdout1_46ck156 = 0.9 time = 785
.meas tran vdout1_46ck156 FIND v(dout1_46) AT=785.025n

* CHECK dout1_47 Vdout1_47ck156 = 0 time = 785
.meas tran vdout1_47ck156 FIND v(dout1_47) AT=785.025n

* CHECK dout1_48 Vdout1_48ck156 = 0.9 time = 785
.meas tran vdout1_48ck156 FIND v(dout1_48) AT=785.025n

* CHECK dout1_49 Vdout1_49ck156 = 0 time = 785
.meas tran vdout1_49ck156 FIND v(dout1_49) AT=785.025n

* CHECK dout1_50 Vdout1_50ck156 = 0.9 time = 785
.meas tran vdout1_50ck156 FIND v(dout1_50) AT=785.025n

* CHECK dout1_51 Vdout1_51ck156 = 0.9 time = 785
.meas tran vdout1_51ck156 FIND v(dout1_51) AT=785.025n

* CHECK dout1_52 Vdout1_52ck156 = 0.9 time = 785
.meas tran vdout1_52ck156 FIND v(dout1_52) AT=785.025n

* CHECK dout1_53 Vdout1_53ck156 = 0 time = 785
.meas tran vdout1_53ck156 FIND v(dout1_53) AT=785.025n

* CHECK dout1_54 Vdout1_54ck156 = 0.9 time = 785
.meas tran vdout1_54ck156 FIND v(dout1_54) AT=785.025n

* CHECK dout1_55 Vdout1_55ck156 = 0 time = 785
.meas tran vdout1_55ck156 FIND v(dout1_55) AT=785.025n

* CHECK dout1_56 Vdout1_56ck156 = 0 time = 785
.meas tran vdout1_56ck156 FIND v(dout1_56) AT=785.025n

* CHECK dout1_57 Vdout1_57ck156 = 0.9 time = 785
.meas tran vdout1_57ck156 FIND v(dout1_57) AT=785.025n

* CHECK dout1_58 Vdout1_58ck156 = 0 time = 785
.meas tran vdout1_58ck156 FIND v(dout1_58) AT=785.025n

* CHECK dout1_59 Vdout1_59ck156 = 0 time = 785
.meas tran vdout1_59ck156 FIND v(dout1_59) AT=785.025n

* CHECK dout1_60 Vdout1_60ck156 = 0.9 time = 785
.meas tran vdout1_60ck156 FIND v(dout1_60) AT=785.025n

* CHECK dout1_61 Vdout1_61ck156 = 0 time = 785
.meas tran vdout1_61ck156 FIND v(dout1_61) AT=785.025n

* CHECK dout1_62 Vdout1_62ck156 = 0 time = 785
.meas tran vdout1_62ck156 FIND v(dout1_62) AT=785.025n

* CHECK dout1_63 Vdout1_63ck156 = 0 time = 785
.meas tran vdout1_63ck156 FIND v(dout1_63) AT=785.025n

* CHECK dout1_64 Vdout1_64ck156 = 0 time = 785
.meas tran vdout1_64ck156 FIND v(dout1_64) AT=785.025n

* CHECK dout1_65 Vdout1_65ck156 = 0 time = 785
.meas tran vdout1_65ck156 FIND v(dout1_65) AT=785.025n

* CHECK dout1_66 Vdout1_66ck156 = 0 time = 785
.meas tran vdout1_66ck156 FIND v(dout1_66) AT=785.025n

* CHECK dout1_67 Vdout1_67ck156 = 0 time = 785
.meas tran vdout1_67ck156 FIND v(dout1_67) AT=785.025n

* CHECK dout1_68 Vdout1_68ck156 = 0.9 time = 785
.meas tran vdout1_68ck156 FIND v(dout1_68) AT=785.025n

* CHECK dout1_69 Vdout1_69ck156 = 0.9 time = 785
.meas tran vdout1_69ck156 FIND v(dout1_69) AT=785.025n

* CHECK dout1_70 Vdout1_70ck156 = 0 time = 785
.meas tran vdout1_70ck156 FIND v(dout1_70) AT=785.025n

* CHECK dout1_71 Vdout1_71ck156 = 0 time = 785
.meas tran vdout1_71ck156 FIND v(dout1_71) AT=785.025n

* CHECK dout1_72 Vdout1_72ck156 = 0 time = 785
.meas tran vdout1_72ck156 FIND v(dout1_72) AT=785.025n

* CHECK dout1_73 Vdout1_73ck156 = 0 time = 785
.meas tran vdout1_73ck156 FIND v(dout1_73) AT=785.025n

* CHECK dout1_74 Vdout1_74ck156 = 0 time = 785
.meas tran vdout1_74ck156 FIND v(dout1_74) AT=785.025n

* CHECK dout1_75 Vdout1_75ck156 = 0 time = 785
.meas tran vdout1_75ck156 FIND v(dout1_75) AT=785.025n

* CHECK dout1_76 Vdout1_76ck156 = 0 time = 785
.meas tran vdout1_76ck156 FIND v(dout1_76) AT=785.025n

* CHECK dout1_77 Vdout1_77ck156 = 0.9 time = 785
.meas tran vdout1_77ck156 FIND v(dout1_77) AT=785.025n

* CHECK dout1_78 Vdout1_78ck156 = 0 time = 785
.meas tran vdout1_78ck156 FIND v(dout1_78) AT=785.025n

* CHECK dout1_79 Vdout1_79ck156 = 0 time = 785
.meas tran vdout1_79ck156 FIND v(dout1_79) AT=785.025n

* CHECK dout1_80 Vdout1_80ck156 = 0 time = 785
.meas tran vdout1_80ck156 FIND v(dout1_80) AT=785.025n

* CHECK dout1_81 Vdout1_81ck156 = 0 time = 785
.meas tran vdout1_81ck156 FIND v(dout1_81) AT=785.025n

* CHECK dout1_82 Vdout1_82ck156 = 0.9 time = 785
.meas tran vdout1_82ck156 FIND v(dout1_82) AT=785.025n

* CHECK dout1_83 Vdout1_83ck156 = 0 time = 785
.meas tran vdout1_83ck156 FIND v(dout1_83) AT=785.025n

* CHECK dout1_84 Vdout1_84ck156 = 0.9 time = 785
.meas tran vdout1_84ck156 FIND v(dout1_84) AT=785.025n

* CHECK dout1_85 Vdout1_85ck156 = 0.9 time = 785
.meas tran vdout1_85ck156 FIND v(dout1_85) AT=785.025n

* CHECK dout1_86 Vdout1_86ck156 = 0.9 time = 785
.meas tran vdout1_86ck156 FIND v(dout1_86) AT=785.025n

* CHECK dout1_87 Vdout1_87ck156 = 0 time = 785
.meas tran vdout1_87ck156 FIND v(dout1_87) AT=785.025n

* CHECK dout1_88 Vdout1_88ck156 = 0.9 time = 785
.meas tran vdout1_88ck156 FIND v(dout1_88) AT=785.025n

* CHECK dout1_89 Vdout1_89ck156 = 0.9 time = 785
.meas tran vdout1_89ck156 FIND v(dout1_89) AT=785.025n

* CHECK dout1_90 Vdout1_90ck156 = 0 time = 785
.meas tran vdout1_90ck156 FIND v(dout1_90) AT=785.025n

* CHECK dout1_91 Vdout1_91ck156 = 0 time = 785
.meas tran vdout1_91ck156 FIND v(dout1_91) AT=785.025n

* CHECK dout1_92 Vdout1_92ck156 = 0 time = 785
.meas tran vdout1_92ck156 FIND v(dout1_92) AT=785.025n

* CHECK dout1_93 Vdout1_93ck156 = 0 time = 785
.meas tran vdout1_93ck156 FIND v(dout1_93) AT=785.025n

* CHECK dout1_94 Vdout1_94ck156 = 0.9 time = 785
.meas tran vdout1_94ck156 FIND v(dout1_94) AT=785.025n

* CHECK dout1_95 Vdout1_95ck156 = 0.9 time = 785
.meas tran vdout1_95ck156 FIND v(dout1_95) AT=785.025n

* CHECK dout1_96 Vdout1_96ck156 = 0 time = 785
.meas tran vdout1_96ck156 FIND v(dout1_96) AT=785.025n

* CHECK dout1_97 Vdout1_97ck156 = 0.9 time = 785
.meas tran vdout1_97ck156 FIND v(dout1_97) AT=785.025n

* CHECK dout1_98 Vdout1_98ck156 = 0.9 time = 785
.meas tran vdout1_98ck156 FIND v(dout1_98) AT=785.025n

* CHECK dout1_99 Vdout1_99ck156 = 0 time = 785
.meas tran vdout1_99ck156 FIND v(dout1_99) AT=785.025n

* CHECK dout1_100 Vdout1_100ck156 = 0 time = 785
.meas tran vdout1_100ck156 FIND v(dout1_100) AT=785.025n

* CHECK dout1_101 Vdout1_101ck156 = 0 time = 785
.meas tran vdout1_101ck156 FIND v(dout1_101) AT=785.025n

* CHECK dout1_102 Vdout1_102ck156 = 0.9 time = 785
.meas tran vdout1_102ck156 FIND v(dout1_102) AT=785.025n

* CHECK dout1_103 Vdout1_103ck156 = 0.9 time = 785
.meas tran vdout1_103ck156 FIND v(dout1_103) AT=785.025n

* CHECK dout1_104 Vdout1_104ck156 = 0 time = 785
.meas tran vdout1_104ck156 FIND v(dout1_104) AT=785.025n

* CHECK dout1_105 Vdout1_105ck156 = 0.9 time = 785
.meas tran vdout1_105ck156 FIND v(dout1_105) AT=785.025n

* CHECK dout1_106 Vdout1_106ck156 = 0.9 time = 785
.meas tran vdout1_106ck156 FIND v(dout1_106) AT=785.025n

* CHECK dout1_107 Vdout1_107ck156 = 0 time = 785
.meas tran vdout1_107ck156 FIND v(dout1_107) AT=785.025n

* CHECK dout1_108 Vdout1_108ck156 = 0.9 time = 785
.meas tran vdout1_108ck156 FIND v(dout1_108) AT=785.025n

* CHECK dout1_109 Vdout1_109ck156 = 0 time = 785
.meas tran vdout1_109ck156 FIND v(dout1_109) AT=785.025n

* CHECK dout1_110 Vdout1_110ck156 = 0 time = 785
.meas tran vdout1_110ck156 FIND v(dout1_110) AT=785.025n

* CHECK dout1_111 Vdout1_111ck156 = 0 time = 785
.meas tran vdout1_111ck156 FIND v(dout1_111) AT=785.025n

* CHECK dout1_112 Vdout1_112ck156 = 0.9 time = 785
.meas tran vdout1_112ck156 FIND v(dout1_112) AT=785.025n

* CHECK dout1_113 Vdout1_113ck156 = 0 time = 785
.meas tran vdout1_113ck156 FIND v(dout1_113) AT=785.025n

* CHECK dout1_114 Vdout1_114ck156 = 0.9 time = 785
.meas tran vdout1_114ck156 FIND v(dout1_114) AT=785.025n

* CHECK dout1_115 Vdout1_115ck156 = 0 time = 785
.meas tran vdout1_115ck156 FIND v(dout1_115) AT=785.025n

* CHECK dout1_116 Vdout1_116ck156 = 0 time = 785
.meas tran vdout1_116ck156 FIND v(dout1_116) AT=785.025n

* CHECK dout1_117 Vdout1_117ck156 = 0 time = 785
.meas tran vdout1_117ck156 FIND v(dout1_117) AT=785.025n

* CHECK dout1_118 Vdout1_118ck156 = 0.9 time = 785
.meas tran vdout1_118ck156 FIND v(dout1_118) AT=785.025n

* CHECK dout1_119 Vdout1_119ck156 = 0.9 time = 785
.meas tran vdout1_119ck156 FIND v(dout1_119) AT=785.025n

* CHECK dout1_0 Vdout1_0ck159 = 0.9 time = 800
.meas tran vdout1_0ck159 FIND v(dout1_0) AT=800.025n

* CHECK dout1_1 Vdout1_1ck159 = 0 time = 800
.meas tran vdout1_1ck159 FIND v(dout1_1) AT=800.025n

* CHECK dout1_2 Vdout1_2ck159 = 0.9 time = 800
.meas tran vdout1_2ck159 FIND v(dout1_2) AT=800.025n

* CHECK dout1_3 Vdout1_3ck159 = 0.9 time = 800
.meas tran vdout1_3ck159 FIND v(dout1_3) AT=800.025n

* CHECK dout1_4 Vdout1_4ck159 = 0 time = 800
.meas tran vdout1_4ck159 FIND v(dout1_4) AT=800.025n

* CHECK dout1_5 Vdout1_5ck159 = 0.9 time = 800
.meas tran vdout1_5ck159 FIND v(dout1_5) AT=800.025n

* CHECK dout1_6 Vdout1_6ck159 = 0.9 time = 800
.meas tran vdout1_6ck159 FIND v(dout1_6) AT=800.025n

* CHECK dout1_7 Vdout1_7ck159 = 0.9 time = 800
.meas tran vdout1_7ck159 FIND v(dout1_7) AT=800.025n

* CHECK dout1_8 Vdout1_8ck159 = 0 time = 800
.meas tran vdout1_8ck159 FIND v(dout1_8) AT=800.025n

* CHECK dout1_9 Vdout1_9ck159 = 0.9 time = 800
.meas tran vdout1_9ck159 FIND v(dout1_9) AT=800.025n

* CHECK dout1_10 Vdout1_10ck159 = 0.9 time = 800
.meas tran vdout1_10ck159 FIND v(dout1_10) AT=800.025n

* CHECK dout1_11 Vdout1_11ck159 = 0.9 time = 800
.meas tran vdout1_11ck159 FIND v(dout1_11) AT=800.025n

* CHECK dout1_12 Vdout1_12ck159 = 0 time = 800
.meas tran vdout1_12ck159 FIND v(dout1_12) AT=800.025n

* CHECK dout1_13 Vdout1_13ck159 = 0 time = 800
.meas tran vdout1_13ck159 FIND v(dout1_13) AT=800.025n

* CHECK dout1_14 Vdout1_14ck159 = 0.9 time = 800
.meas tran vdout1_14ck159 FIND v(dout1_14) AT=800.025n

* CHECK dout1_15 Vdout1_15ck159 = 0.9 time = 800
.meas tran vdout1_15ck159 FIND v(dout1_15) AT=800.025n

* CHECK dout1_16 Vdout1_16ck159 = 0.9 time = 800
.meas tran vdout1_16ck159 FIND v(dout1_16) AT=800.025n

* CHECK dout1_17 Vdout1_17ck159 = 0 time = 800
.meas tran vdout1_17ck159 FIND v(dout1_17) AT=800.025n

* CHECK dout1_18 Vdout1_18ck159 = 0 time = 800
.meas tran vdout1_18ck159 FIND v(dout1_18) AT=800.025n

* CHECK dout1_19 Vdout1_19ck159 = 0 time = 800
.meas tran vdout1_19ck159 FIND v(dout1_19) AT=800.025n

* CHECK dout1_20 Vdout1_20ck159 = 0 time = 800
.meas tran vdout1_20ck159 FIND v(dout1_20) AT=800.025n

* CHECK dout1_21 Vdout1_21ck159 = 0 time = 800
.meas tran vdout1_21ck159 FIND v(dout1_21) AT=800.025n

* CHECK dout1_22 Vdout1_22ck159 = 0.9 time = 800
.meas tran vdout1_22ck159 FIND v(dout1_22) AT=800.025n

* CHECK dout1_23 Vdout1_23ck159 = 0.9 time = 800
.meas tran vdout1_23ck159 FIND v(dout1_23) AT=800.025n

* CHECK dout1_24 Vdout1_24ck159 = 0.9 time = 800
.meas tran vdout1_24ck159 FIND v(dout1_24) AT=800.025n

* CHECK dout1_25 Vdout1_25ck159 = 0.9 time = 800
.meas tran vdout1_25ck159 FIND v(dout1_25) AT=800.025n

* CHECK dout1_26 Vdout1_26ck159 = 0 time = 800
.meas tran vdout1_26ck159 FIND v(dout1_26) AT=800.025n

* CHECK dout1_27 Vdout1_27ck159 = 0.9 time = 800
.meas tran vdout1_27ck159 FIND v(dout1_27) AT=800.025n

* CHECK dout1_28 Vdout1_28ck159 = 0.9 time = 800
.meas tran vdout1_28ck159 FIND v(dout1_28) AT=800.025n

* CHECK dout1_29 Vdout1_29ck159 = 0.9 time = 800
.meas tran vdout1_29ck159 FIND v(dout1_29) AT=800.025n

* CHECK dout1_30 Vdout1_30ck159 = 0 time = 800
.meas tran vdout1_30ck159 FIND v(dout1_30) AT=800.025n

* CHECK dout1_31 Vdout1_31ck159 = 0 time = 800
.meas tran vdout1_31ck159 FIND v(dout1_31) AT=800.025n

* CHECK dout1_32 Vdout1_32ck159 = 0 time = 800
.meas tran vdout1_32ck159 FIND v(dout1_32) AT=800.025n

* CHECK dout1_33 Vdout1_33ck159 = 0 time = 800
.meas tran vdout1_33ck159 FIND v(dout1_33) AT=800.025n

* CHECK dout1_34 Vdout1_34ck159 = 0 time = 800
.meas tran vdout1_34ck159 FIND v(dout1_34) AT=800.025n

* CHECK dout1_35 Vdout1_35ck159 = 0.9 time = 800
.meas tran vdout1_35ck159 FIND v(dout1_35) AT=800.025n

* CHECK dout1_36 Vdout1_36ck159 = 0 time = 800
.meas tran vdout1_36ck159 FIND v(dout1_36) AT=800.025n

* CHECK dout1_37 Vdout1_37ck159 = 0.9 time = 800
.meas tran vdout1_37ck159 FIND v(dout1_37) AT=800.025n

* CHECK dout1_38 Vdout1_38ck159 = 0 time = 800
.meas tran vdout1_38ck159 FIND v(dout1_38) AT=800.025n

* CHECK dout1_39 Vdout1_39ck159 = 0 time = 800
.meas tran vdout1_39ck159 FIND v(dout1_39) AT=800.025n

* CHECK dout1_40 Vdout1_40ck159 = 0 time = 800
.meas tran vdout1_40ck159 FIND v(dout1_40) AT=800.025n

* CHECK dout1_41 Vdout1_41ck159 = 0 time = 800
.meas tran vdout1_41ck159 FIND v(dout1_41) AT=800.025n

* CHECK dout1_42 Vdout1_42ck159 = 0 time = 800
.meas tran vdout1_42ck159 FIND v(dout1_42) AT=800.025n

* CHECK dout1_43 Vdout1_43ck159 = 0.9 time = 800
.meas tran vdout1_43ck159 FIND v(dout1_43) AT=800.025n

* CHECK dout1_44 Vdout1_44ck159 = 0.9 time = 800
.meas tran vdout1_44ck159 FIND v(dout1_44) AT=800.025n

* CHECK dout1_45 Vdout1_45ck159 = 0.9 time = 800
.meas tran vdout1_45ck159 FIND v(dout1_45) AT=800.025n

* CHECK dout1_46 Vdout1_46ck159 = 0 time = 800
.meas tran vdout1_46ck159 FIND v(dout1_46) AT=800.025n

* CHECK dout1_47 Vdout1_47ck159 = 0.9 time = 800
.meas tran vdout1_47ck159 FIND v(dout1_47) AT=800.025n

* CHECK dout1_48 Vdout1_48ck159 = 0.9 time = 800
.meas tran vdout1_48ck159 FIND v(dout1_48) AT=800.025n

* CHECK dout1_49 Vdout1_49ck159 = 0.9 time = 800
.meas tran vdout1_49ck159 FIND v(dout1_49) AT=800.025n

* CHECK dout1_50 Vdout1_50ck159 = 0 time = 800
.meas tran vdout1_50ck159 FIND v(dout1_50) AT=800.025n

* CHECK dout1_51 Vdout1_51ck159 = 0 time = 800
.meas tran vdout1_51ck159 FIND v(dout1_51) AT=800.025n

* CHECK dout1_52 Vdout1_52ck159 = 0.9 time = 800
.meas tran vdout1_52ck159 FIND v(dout1_52) AT=800.025n

* CHECK dout1_53 Vdout1_53ck159 = 0 time = 800
.meas tran vdout1_53ck159 FIND v(dout1_53) AT=800.025n

* CHECK dout1_54 Vdout1_54ck159 = 0.9 time = 800
.meas tran vdout1_54ck159 FIND v(dout1_54) AT=800.025n

* CHECK dout1_55 Vdout1_55ck159 = 0 time = 800
.meas tran vdout1_55ck159 FIND v(dout1_55) AT=800.025n

* CHECK dout1_56 Vdout1_56ck159 = 0.9 time = 800
.meas tran vdout1_56ck159 FIND v(dout1_56) AT=800.025n

* CHECK dout1_57 Vdout1_57ck159 = 0.9 time = 800
.meas tran vdout1_57ck159 FIND v(dout1_57) AT=800.025n

* CHECK dout1_58 Vdout1_58ck159 = 0 time = 800
.meas tran vdout1_58ck159 FIND v(dout1_58) AT=800.025n

* CHECK dout1_59 Vdout1_59ck159 = 0 time = 800
.meas tran vdout1_59ck159 FIND v(dout1_59) AT=800.025n

* CHECK dout1_60 Vdout1_60ck159 = 0.9 time = 800
.meas tran vdout1_60ck159 FIND v(dout1_60) AT=800.025n

* CHECK dout1_61 Vdout1_61ck159 = 0.9 time = 800
.meas tran vdout1_61ck159 FIND v(dout1_61) AT=800.025n

* CHECK dout1_62 Vdout1_62ck159 = 0 time = 800
.meas tran vdout1_62ck159 FIND v(dout1_62) AT=800.025n

* CHECK dout1_63 Vdout1_63ck159 = 0.9 time = 800
.meas tran vdout1_63ck159 FIND v(dout1_63) AT=800.025n

* CHECK dout1_64 Vdout1_64ck159 = 0 time = 800
.meas tran vdout1_64ck159 FIND v(dout1_64) AT=800.025n

* CHECK dout1_65 Vdout1_65ck159 = 0.9 time = 800
.meas tran vdout1_65ck159 FIND v(dout1_65) AT=800.025n

* CHECK dout1_66 Vdout1_66ck159 = 0.9 time = 800
.meas tran vdout1_66ck159 FIND v(dout1_66) AT=800.025n

* CHECK dout1_67 Vdout1_67ck159 = 0 time = 800
.meas tran vdout1_67ck159 FIND v(dout1_67) AT=800.025n

* CHECK dout1_68 Vdout1_68ck159 = 0.9 time = 800
.meas tran vdout1_68ck159 FIND v(dout1_68) AT=800.025n

* CHECK dout1_69 Vdout1_69ck159 = 0 time = 800
.meas tran vdout1_69ck159 FIND v(dout1_69) AT=800.025n

* CHECK dout1_70 Vdout1_70ck159 = 0.9 time = 800
.meas tran vdout1_70ck159 FIND v(dout1_70) AT=800.025n

* CHECK dout1_71 Vdout1_71ck159 = 0 time = 800
.meas tran vdout1_71ck159 FIND v(dout1_71) AT=800.025n

* CHECK dout1_72 Vdout1_72ck159 = 0.9 time = 800
.meas tran vdout1_72ck159 FIND v(dout1_72) AT=800.025n

* CHECK dout1_73 Vdout1_73ck159 = 0.9 time = 800
.meas tran vdout1_73ck159 FIND v(dout1_73) AT=800.025n

* CHECK dout1_74 Vdout1_74ck159 = 0.9 time = 800
.meas tran vdout1_74ck159 FIND v(dout1_74) AT=800.025n

* CHECK dout1_75 Vdout1_75ck159 = 0 time = 800
.meas tran vdout1_75ck159 FIND v(dout1_75) AT=800.025n

* CHECK dout1_76 Vdout1_76ck159 = 0.9 time = 800
.meas tran vdout1_76ck159 FIND v(dout1_76) AT=800.025n

* CHECK dout1_77 Vdout1_77ck159 = 0.9 time = 800
.meas tran vdout1_77ck159 FIND v(dout1_77) AT=800.025n

* CHECK dout1_78 Vdout1_78ck159 = 0.9 time = 800
.meas tran vdout1_78ck159 FIND v(dout1_78) AT=800.025n

* CHECK dout1_79 Vdout1_79ck159 = 0.9 time = 800
.meas tran vdout1_79ck159 FIND v(dout1_79) AT=800.025n

* CHECK dout1_80 Vdout1_80ck159 = 0 time = 800
.meas tran vdout1_80ck159 FIND v(dout1_80) AT=800.025n

* CHECK dout1_81 Vdout1_81ck159 = 0.9 time = 800
.meas tran vdout1_81ck159 FIND v(dout1_81) AT=800.025n

* CHECK dout1_82 Vdout1_82ck159 = 0.9 time = 800
.meas tran vdout1_82ck159 FIND v(dout1_82) AT=800.025n

* CHECK dout1_83 Vdout1_83ck159 = 0.9 time = 800
.meas tran vdout1_83ck159 FIND v(dout1_83) AT=800.025n

* CHECK dout1_84 Vdout1_84ck159 = 0 time = 800
.meas tran vdout1_84ck159 FIND v(dout1_84) AT=800.025n

* CHECK dout1_85 Vdout1_85ck159 = 0 time = 800
.meas tran vdout1_85ck159 FIND v(dout1_85) AT=800.025n

* CHECK dout1_86 Vdout1_86ck159 = 0.9 time = 800
.meas tran vdout1_86ck159 FIND v(dout1_86) AT=800.025n

* CHECK dout1_87 Vdout1_87ck159 = 0 time = 800
.meas tran vdout1_87ck159 FIND v(dout1_87) AT=800.025n

* CHECK dout1_88 Vdout1_88ck159 = 0 time = 800
.meas tran vdout1_88ck159 FIND v(dout1_88) AT=800.025n

* CHECK dout1_89 Vdout1_89ck159 = 0 time = 800
.meas tran vdout1_89ck159 FIND v(dout1_89) AT=800.025n

* CHECK dout1_90 Vdout1_90ck159 = 0.9 time = 800
.meas tran vdout1_90ck159 FIND v(dout1_90) AT=800.025n

* CHECK dout1_91 Vdout1_91ck159 = 0 time = 800
.meas tran vdout1_91ck159 FIND v(dout1_91) AT=800.025n

* CHECK dout1_92 Vdout1_92ck159 = 0 time = 800
.meas tran vdout1_92ck159 FIND v(dout1_92) AT=800.025n

* CHECK dout1_93 Vdout1_93ck159 = 0.9 time = 800
.meas tran vdout1_93ck159 FIND v(dout1_93) AT=800.025n

* CHECK dout1_94 Vdout1_94ck159 = 0.9 time = 800
.meas tran vdout1_94ck159 FIND v(dout1_94) AT=800.025n

* CHECK dout1_95 Vdout1_95ck159 = 0 time = 800
.meas tran vdout1_95ck159 FIND v(dout1_95) AT=800.025n

* CHECK dout1_96 Vdout1_96ck159 = 0 time = 800
.meas tran vdout1_96ck159 FIND v(dout1_96) AT=800.025n

* CHECK dout1_97 Vdout1_97ck159 = 0.9 time = 800
.meas tran vdout1_97ck159 FIND v(dout1_97) AT=800.025n

* CHECK dout1_98 Vdout1_98ck159 = 0.9 time = 800
.meas tran vdout1_98ck159 FIND v(dout1_98) AT=800.025n

* CHECK dout1_99 Vdout1_99ck159 = 0 time = 800
.meas tran vdout1_99ck159 FIND v(dout1_99) AT=800.025n

* CHECK dout1_100 Vdout1_100ck159 = 0 time = 800
.meas tran vdout1_100ck159 FIND v(dout1_100) AT=800.025n

* CHECK dout1_101 Vdout1_101ck159 = 0.9 time = 800
.meas tran vdout1_101ck159 FIND v(dout1_101) AT=800.025n

* CHECK dout1_102 Vdout1_102ck159 = 0 time = 800
.meas tran vdout1_102ck159 FIND v(dout1_102) AT=800.025n

* CHECK dout1_103 Vdout1_103ck159 = 0 time = 800
.meas tran vdout1_103ck159 FIND v(dout1_103) AT=800.025n

* CHECK dout1_104 Vdout1_104ck159 = 0.9 time = 800
.meas tran vdout1_104ck159 FIND v(dout1_104) AT=800.025n

* CHECK dout1_105 Vdout1_105ck159 = 0.9 time = 800
.meas tran vdout1_105ck159 FIND v(dout1_105) AT=800.025n

* CHECK dout1_106 Vdout1_106ck159 = 0.9 time = 800
.meas tran vdout1_106ck159 FIND v(dout1_106) AT=800.025n

* CHECK dout1_107 Vdout1_107ck159 = 0 time = 800
.meas tran vdout1_107ck159 FIND v(dout1_107) AT=800.025n

* CHECK dout1_108 Vdout1_108ck159 = 0.9 time = 800
.meas tran vdout1_108ck159 FIND v(dout1_108) AT=800.025n

* CHECK dout1_109 Vdout1_109ck159 = 0 time = 800
.meas tran vdout1_109ck159 FIND v(dout1_109) AT=800.025n

* CHECK dout1_110 Vdout1_110ck159 = 0 time = 800
.meas tran vdout1_110ck159 FIND v(dout1_110) AT=800.025n

* CHECK dout1_111 Vdout1_111ck159 = 0.9 time = 800
.meas tran vdout1_111ck159 FIND v(dout1_111) AT=800.025n

* CHECK dout1_112 Vdout1_112ck159 = 0.9 time = 800
.meas tran vdout1_112ck159 FIND v(dout1_112) AT=800.025n

* CHECK dout1_113 Vdout1_113ck159 = 0 time = 800
.meas tran vdout1_113ck159 FIND v(dout1_113) AT=800.025n

* CHECK dout1_114 Vdout1_114ck159 = 0 time = 800
.meas tran vdout1_114ck159 FIND v(dout1_114) AT=800.025n

* CHECK dout1_115 Vdout1_115ck159 = 0 time = 800
.meas tran vdout1_115ck159 FIND v(dout1_115) AT=800.025n

* CHECK dout1_116 Vdout1_116ck159 = 0.9 time = 800
.meas tran vdout1_116ck159 FIND v(dout1_116) AT=800.025n

* CHECK dout1_117 Vdout1_117ck159 = 0.9 time = 800
.meas tran vdout1_117ck159 FIND v(dout1_117) AT=800.025n

* CHECK dout1_118 Vdout1_118ck159 = 0 time = 800
.meas tran vdout1_118ck159 FIND v(dout1_118) AT=800.025n

* CHECK dout1_119 Vdout1_119ck159 = 0 time = 800
.meas tran vdout1_119ck159 FIND v(dout1_119) AT=800.025n

* CHECK dout1_0 Vdout1_0ck161 = 0.9 time = 810
.meas tran vdout1_0ck161 FIND v(dout1_0) AT=810.025n

* CHECK dout1_1 Vdout1_1ck161 = 0 time = 810
.meas tran vdout1_1ck161 FIND v(dout1_1) AT=810.025n

* CHECK dout1_2 Vdout1_2ck161 = 0.9 time = 810
.meas tran vdout1_2ck161 FIND v(dout1_2) AT=810.025n

* CHECK dout1_3 Vdout1_3ck161 = 0 time = 810
.meas tran vdout1_3ck161 FIND v(dout1_3) AT=810.025n

* CHECK dout1_4 Vdout1_4ck161 = 0.9 time = 810
.meas tran vdout1_4ck161 FIND v(dout1_4) AT=810.025n

* CHECK dout1_5 Vdout1_5ck161 = 0 time = 810
.meas tran vdout1_5ck161 FIND v(dout1_5) AT=810.025n

* CHECK dout1_6 Vdout1_6ck161 = 0 time = 810
.meas tran vdout1_6ck161 FIND v(dout1_6) AT=810.025n

* CHECK dout1_7 Vdout1_7ck161 = 0 time = 810
.meas tran vdout1_7ck161 FIND v(dout1_7) AT=810.025n

* CHECK dout1_8 Vdout1_8ck161 = 0.9 time = 810
.meas tran vdout1_8ck161 FIND v(dout1_8) AT=810.025n

* CHECK dout1_9 Vdout1_9ck161 = 0.9 time = 810
.meas tran vdout1_9ck161 FIND v(dout1_9) AT=810.025n

* CHECK dout1_10 Vdout1_10ck161 = 0 time = 810
.meas tran vdout1_10ck161 FIND v(dout1_10) AT=810.025n

* CHECK dout1_11 Vdout1_11ck161 = 0.9 time = 810
.meas tran vdout1_11ck161 FIND v(dout1_11) AT=810.025n

* CHECK dout1_12 Vdout1_12ck161 = 0.9 time = 810
.meas tran vdout1_12ck161 FIND v(dout1_12) AT=810.025n

* CHECK dout1_13 Vdout1_13ck161 = 0.9 time = 810
.meas tran vdout1_13ck161 FIND v(dout1_13) AT=810.025n

* CHECK dout1_14 Vdout1_14ck161 = 0 time = 810
.meas tran vdout1_14ck161 FIND v(dout1_14) AT=810.025n

* CHECK dout1_15 Vdout1_15ck161 = 0 time = 810
.meas tran vdout1_15ck161 FIND v(dout1_15) AT=810.025n

* CHECK dout1_16 Vdout1_16ck161 = 0 time = 810
.meas tran vdout1_16ck161 FIND v(dout1_16) AT=810.025n

* CHECK dout1_17 Vdout1_17ck161 = 0.9 time = 810
.meas tran vdout1_17ck161 FIND v(dout1_17) AT=810.025n

* CHECK dout1_18 Vdout1_18ck161 = 0 time = 810
.meas tran vdout1_18ck161 FIND v(dout1_18) AT=810.025n

* CHECK dout1_19 Vdout1_19ck161 = 0 time = 810
.meas tran vdout1_19ck161 FIND v(dout1_19) AT=810.025n

* CHECK dout1_20 Vdout1_20ck161 = 0.9 time = 810
.meas tran vdout1_20ck161 FIND v(dout1_20) AT=810.025n

* CHECK dout1_21 Vdout1_21ck161 = 0.9 time = 810
.meas tran vdout1_21ck161 FIND v(dout1_21) AT=810.025n

* CHECK dout1_22 Vdout1_22ck161 = 0 time = 810
.meas tran vdout1_22ck161 FIND v(dout1_22) AT=810.025n

* CHECK dout1_23 Vdout1_23ck161 = 0 time = 810
.meas tran vdout1_23ck161 FIND v(dout1_23) AT=810.025n

* CHECK dout1_24 Vdout1_24ck161 = 0 time = 810
.meas tran vdout1_24ck161 FIND v(dout1_24) AT=810.025n

* CHECK dout1_25 Vdout1_25ck161 = 0 time = 810
.meas tran vdout1_25ck161 FIND v(dout1_25) AT=810.025n

* CHECK dout1_26 Vdout1_26ck161 = 0.9 time = 810
.meas tran vdout1_26ck161 FIND v(dout1_26) AT=810.025n

* CHECK dout1_27 Vdout1_27ck161 = 0.9 time = 810
.meas tran vdout1_27ck161 FIND v(dout1_27) AT=810.025n

* CHECK dout1_28 Vdout1_28ck161 = 0 time = 810
.meas tran vdout1_28ck161 FIND v(dout1_28) AT=810.025n

* CHECK dout1_29 Vdout1_29ck161 = 0 time = 810
.meas tran vdout1_29ck161 FIND v(dout1_29) AT=810.025n

* CHECK dout1_30 Vdout1_30ck161 = 0.9 time = 810
.meas tran vdout1_30ck161 FIND v(dout1_30) AT=810.025n

* CHECK dout1_31 Vdout1_31ck161 = 0 time = 810
.meas tran vdout1_31ck161 FIND v(dout1_31) AT=810.025n

* CHECK dout1_32 Vdout1_32ck161 = 0.9 time = 810
.meas tran vdout1_32ck161 FIND v(dout1_32) AT=810.025n

* CHECK dout1_33 Vdout1_33ck161 = 0 time = 810
.meas tran vdout1_33ck161 FIND v(dout1_33) AT=810.025n

* CHECK dout1_34 Vdout1_34ck161 = 0 time = 810
.meas tran vdout1_34ck161 FIND v(dout1_34) AT=810.025n

* CHECK dout1_35 Vdout1_35ck161 = 0.9 time = 810
.meas tran vdout1_35ck161 FIND v(dout1_35) AT=810.025n

* CHECK dout1_36 Vdout1_36ck161 = 0 time = 810
.meas tran vdout1_36ck161 FIND v(dout1_36) AT=810.025n

* CHECK dout1_37 Vdout1_37ck161 = 0.9 time = 810
.meas tran vdout1_37ck161 FIND v(dout1_37) AT=810.025n

* CHECK dout1_38 Vdout1_38ck161 = 0.9 time = 810
.meas tran vdout1_38ck161 FIND v(dout1_38) AT=810.025n

* CHECK dout1_39 Vdout1_39ck161 = 0 time = 810
.meas tran vdout1_39ck161 FIND v(dout1_39) AT=810.025n

* CHECK dout1_40 Vdout1_40ck161 = 0.9 time = 810
.meas tran vdout1_40ck161 FIND v(dout1_40) AT=810.025n

* CHECK dout1_41 Vdout1_41ck161 = 0.9 time = 810
.meas tran vdout1_41ck161 FIND v(dout1_41) AT=810.025n

* CHECK dout1_42 Vdout1_42ck161 = 0 time = 810
.meas tran vdout1_42ck161 FIND v(dout1_42) AT=810.025n

* CHECK dout1_43 Vdout1_43ck161 = 0 time = 810
.meas tran vdout1_43ck161 FIND v(dout1_43) AT=810.025n

* CHECK dout1_44 Vdout1_44ck161 = 0.9 time = 810
.meas tran vdout1_44ck161 FIND v(dout1_44) AT=810.025n

* CHECK dout1_45 Vdout1_45ck161 = 0.9 time = 810
.meas tran vdout1_45ck161 FIND v(dout1_45) AT=810.025n

* CHECK dout1_46 Vdout1_46ck161 = 0.9 time = 810
.meas tran vdout1_46ck161 FIND v(dout1_46) AT=810.025n

* CHECK dout1_47 Vdout1_47ck161 = 0.9 time = 810
.meas tran vdout1_47ck161 FIND v(dout1_47) AT=810.025n

* CHECK dout1_48 Vdout1_48ck161 = 0.9 time = 810
.meas tran vdout1_48ck161 FIND v(dout1_48) AT=810.025n

* CHECK dout1_49 Vdout1_49ck161 = 0.9 time = 810
.meas tran vdout1_49ck161 FIND v(dout1_49) AT=810.025n

* CHECK dout1_50 Vdout1_50ck161 = 0 time = 810
.meas tran vdout1_50ck161 FIND v(dout1_50) AT=810.025n

* CHECK dout1_51 Vdout1_51ck161 = 0.9 time = 810
.meas tran vdout1_51ck161 FIND v(dout1_51) AT=810.025n

* CHECK dout1_52 Vdout1_52ck161 = 0 time = 810
.meas tran vdout1_52ck161 FIND v(dout1_52) AT=810.025n

* CHECK dout1_53 Vdout1_53ck161 = 0 time = 810
.meas tran vdout1_53ck161 FIND v(dout1_53) AT=810.025n

* CHECK dout1_54 Vdout1_54ck161 = 0 time = 810
.meas tran vdout1_54ck161 FIND v(dout1_54) AT=810.025n

* CHECK dout1_55 Vdout1_55ck161 = 0 time = 810
.meas tran vdout1_55ck161 FIND v(dout1_55) AT=810.025n

* CHECK dout1_56 Vdout1_56ck161 = 0.9 time = 810
.meas tran vdout1_56ck161 FIND v(dout1_56) AT=810.025n

* CHECK dout1_57 Vdout1_57ck161 = 0.9 time = 810
.meas tran vdout1_57ck161 FIND v(dout1_57) AT=810.025n

* CHECK dout1_58 Vdout1_58ck161 = 0 time = 810
.meas tran vdout1_58ck161 FIND v(dout1_58) AT=810.025n

* CHECK dout1_59 Vdout1_59ck161 = 0 time = 810
.meas tran vdout1_59ck161 FIND v(dout1_59) AT=810.025n

* CHECK dout1_60 Vdout1_60ck161 = 0.9 time = 810
.meas tran vdout1_60ck161 FIND v(dout1_60) AT=810.025n

* CHECK dout1_61 Vdout1_61ck161 = 0.9 time = 810
.meas tran vdout1_61ck161 FIND v(dout1_61) AT=810.025n

* CHECK dout1_62 Vdout1_62ck161 = 0.9 time = 810
.meas tran vdout1_62ck161 FIND v(dout1_62) AT=810.025n

* CHECK dout1_63 Vdout1_63ck161 = 0.9 time = 810
.meas tran vdout1_63ck161 FIND v(dout1_63) AT=810.025n

* CHECK dout1_64 Vdout1_64ck161 = 0 time = 810
.meas tran vdout1_64ck161 FIND v(dout1_64) AT=810.025n

* CHECK dout1_65 Vdout1_65ck161 = 0 time = 810
.meas tran vdout1_65ck161 FIND v(dout1_65) AT=810.025n

* CHECK dout1_66 Vdout1_66ck161 = 0.9 time = 810
.meas tran vdout1_66ck161 FIND v(dout1_66) AT=810.025n

* CHECK dout1_67 Vdout1_67ck161 = 0.9 time = 810
.meas tran vdout1_67ck161 FIND v(dout1_67) AT=810.025n

* CHECK dout1_68 Vdout1_68ck161 = 0 time = 810
.meas tran vdout1_68ck161 FIND v(dout1_68) AT=810.025n

* CHECK dout1_69 Vdout1_69ck161 = 0 time = 810
.meas tran vdout1_69ck161 FIND v(dout1_69) AT=810.025n

* CHECK dout1_70 Vdout1_70ck161 = 0 time = 810
.meas tran vdout1_70ck161 FIND v(dout1_70) AT=810.025n

* CHECK dout1_71 Vdout1_71ck161 = 0.9 time = 810
.meas tran vdout1_71ck161 FIND v(dout1_71) AT=810.025n

* CHECK dout1_72 Vdout1_72ck161 = 0 time = 810
.meas tran vdout1_72ck161 FIND v(dout1_72) AT=810.025n

* CHECK dout1_73 Vdout1_73ck161 = 0 time = 810
.meas tran vdout1_73ck161 FIND v(dout1_73) AT=810.025n

* CHECK dout1_74 Vdout1_74ck161 = 0.9 time = 810
.meas tran vdout1_74ck161 FIND v(dout1_74) AT=810.025n

* CHECK dout1_75 Vdout1_75ck161 = 0 time = 810
.meas tran vdout1_75ck161 FIND v(dout1_75) AT=810.025n

* CHECK dout1_76 Vdout1_76ck161 = 0 time = 810
.meas tran vdout1_76ck161 FIND v(dout1_76) AT=810.025n

* CHECK dout1_77 Vdout1_77ck161 = 0.9 time = 810
.meas tran vdout1_77ck161 FIND v(dout1_77) AT=810.025n

* CHECK dout1_78 Vdout1_78ck161 = 0.9 time = 810
.meas tran vdout1_78ck161 FIND v(dout1_78) AT=810.025n

* CHECK dout1_79 Vdout1_79ck161 = 0 time = 810
.meas tran vdout1_79ck161 FIND v(dout1_79) AT=810.025n

* CHECK dout1_80 Vdout1_80ck161 = 0 time = 810
.meas tran vdout1_80ck161 FIND v(dout1_80) AT=810.025n

* CHECK dout1_81 Vdout1_81ck161 = 0 time = 810
.meas tran vdout1_81ck161 FIND v(dout1_81) AT=810.025n

* CHECK dout1_82 Vdout1_82ck161 = 0 time = 810
.meas tran vdout1_82ck161 FIND v(dout1_82) AT=810.025n

* CHECK dout1_83 Vdout1_83ck161 = 0.9 time = 810
.meas tran vdout1_83ck161 FIND v(dout1_83) AT=810.025n

* CHECK dout1_84 Vdout1_84ck161 = 0.9 time = 810
.meas tran vdout1_84ck161 FIND v(dout1_84) AT=810.025n

* CHECK dout1_85 Vdout1_85ck161 = 0 time = 810
.meas tran vdout1_85ck161 FIND v(dout1_85) AT=810.025n

* CHECK dout1_86 Vdout1_86ck161 = 0.9 time = 810
.meas tran vdout1_86ck161 FIND v(dout1_86) AT=810.025n

* CHECK dout1_87 Vdout1_87ck161 = 0 time = 810
.meas tran vdout1_87ck161 FIND v(dout1_87) AT=810.025n

* CHECK dout1_88 Vdout1_88ck161 = 0 time = 810
.meas tran vdout1_88ck161 FIND v(dout1_88) AT=810.025n

* CHECK dout1_89 Vdout1_89ck161 = 0.9 time = 810
.meas tran vdout1_89ck161 FIND v(dout1_89) AT=810.025n

* CHECK dout1_90 Vdout1_90ck161 = 0 time = 810
.meas tran vdout1_90ck161 FIND v(dout1_90) AT=810.025n

* CHECK dout1_91 Vdout1_91ck161 = 0.9 time = 810
.meas tran vdout1_91ck161 FIND v(dout1_91) AT=810.025n

* CHECK dout1_92 Vdout1_92ck161 = 0.9 time = 810
.meas tran vdout1_92ck161 FIND v(dout1_92) AT=810.025n

* CHECK dout1_93 Vdout1_93ck161 = 0.9 time = 810
.meas tran vdout1_93ck161 FIND v(dout1_93) AT=810.025n

* CHECK dout1_94 Vdout1_94ck161 = 0 time = 810
.meas tran vdout1_94ck161 FIND v(dout1_94) AT=810.025n

* CHECK dout1_95 Vdout1_95ck161 = 0 time = 810
.meas tran vdout1_95ck161 FIND v(dout1_95) AT=810.025n

* CHECK dout1_96 Vdout1_96ck161 = 0.9 time = 810
.meas tran vdout1_96ck161 FIND v(dout1_96) AT=810.025n

* CHECK dout1_97 Vdout1_97ck161 = 0.9 time = 810
.meas tran vdout1_97ck161 FIND v(dout1_97) AT=810.025n

* CHECK dout1_98 Vdout1_98ck161 = 0 time = 810
.meas tran vdout1_98ck161 FIND v(dout1_98) AT=810.025n

* CHECK dout1_99 Vdout1_99ck161 = 0.9 time = 810
.meas tran vdout1_99ck161 FIND v(dout1_99) AT=810.025n

* CHECK dout1_100 Vdout1_100ck161 = 0 time = 810
.meas tran vdout1_100ck161 FIND v(dout1_100) AT=810.025n

* CHECK dout1_101 Vdout1_101ck161 = 0.9 time = 810
.meas tran vdout1_101ck161 FIND v(dout1_101) AT=810.025n

* CHECK dout1_102 Vdout1_102ck161 = 0 time = 810
.meas tran vdout1_102ck161 FIND v(dout1_102) AT=810.025n

* CHECK dout1_103 Vdout1_103ck161 = 0 time = 810
.meas tran vdout1_103ck161 FIND v(dout1_103) AT=810.025n

* CHECK dout1_104 Vdout1_104ck161 = 0.9 time = 810
.meas tran vdout1_104ck161 FIND v(dout1_104) AT=810.025n

* CHECK dout1_105 Vdout1_105ck161 = 0 time = 810
.meas tran vdout1_105ck161 FIND v(dout1_105) AT=810.025n

* CHECK dout1_106 Vdout1_106ck161 = 0 time = 810
.meas tran vdout1_106ck161 FIND v(dout1_106) AT=810.025n

* CHECK dout1_107 Vdout1_107ck161 = 0 time = 810
.meas tran vdout1_107ck161 FIND v(dout1_107) AT=810.025n

* CHECK dout1_108 Vdout1_108ck161 = 0 time = 810
.meas tran vdout1_108ck161 FIND v(dout1_108) AT=810.025n

* CHECK dout1_109 Vdout1_109ck161 = 0.9 time = 810
.meas tran vdout1_109ck161 FIND v(dout1_109) AT=810.025n

* CHECK dout1_110 Vdout1_110ck161 = 0 time = 810
.meas tran vdout1_110ck161 FIND v(dout1_110) AT=810.025n

* CHECK dout1_111 Vdout1_111ck161 = 0.9 time = 810
.meas tran vdout1_111ck161 FIND v(dout1_111) AT=810.025n

* CHECK dout1_112 Vdout1_112ck161 = 0 time = 810
.meas tran vdout1_112ck161 FIND v(dout1_112) AT=810.025n

* CHECK dout1_113 Vdout1_113ck161 = 0 time = 810
.meas tran vdout1_113ck161 FIND v(dout1_113) AT=810.025n

* CHECK dout1_114 Vdout1_114ck161 = 0 time = 810
.meas tran vdout1_114ck161 FIND v(dout1_114) AT=810.025n

* CHECK dout1_115 Vdout1_115ck161 = 0 time = 810
.meas tran vdout1_115ck161 FIND v(dout1_115) AT=810.025n

* CHECK dout1_116 Vdout1_116ck161 = 0.9 time = 810
.meas tran vdout1_116ck161 FIND v(dout1_116) AT=810.025n

* CHECK dout1_117 Vdout1_117ck161 = 0 time = 810
.meas tran vdout1_117ck161 FIND v(dout1_117) AT=810.025n

* CHECK dout1_118 Vdout1_118ck161 = 0.9 time = 810
.meas tran vdout1_118ck161 FIND v(dout1_118) AT=810.025n

* CHECK dout1_119 Vdout1_119ck161 = 0.9 time = 810
.meas tran vdout1_119ck161 FIND v(dout1_119) AT=810.025n

* CHECK dout1_0 Vdout1_0ck166 = 0 time = 835
.meas tran vdout1_0ck166 FIND v(dout1_0) AT=835.025n

* CHECK dout1_1 Vdout1_1ck166 = 0.9 time = 835
.meas tran vdout1_1ck166 FIND v(dout1_1) AT=835.025n

* CHECK dout1_2 Vdout1_2ck166 = 0 time = 835
.meas tran vdout1_2ck166 FIND v(dout1_2) AT=835.025n

* CHECK dout1_3 Vdout1_3ck166 = 0.9 time = 835
.meas tran vdout1_3ck166 FIND v(dout1_3) AT=835.025n

* CHECK dout1_4 Vdout1_4ck166 = 0.9 time = 835
.meas tran vdout1_4ck166 FIND v(dout1_4) AT=835.025n

* CHECK dout1_5 Vdout1_5ck166 = 0.9 time = 835
.meas tran vdout1_5ck166 FIND v(dout1_5) AT=835.025n

* CHECK dout1_6 Vdout1_6ck166 = 0 time = 835
.meas tran vdout1_6ck166 FIND v(dout1_6) AT=835.025n

* CHECK dout1_7 Vdout1_7ck166 = 0.9 time = 835
.meas tran vdout1_7ck166 FIND v(dout1_7) AT=835.025n

* CHECK dout1_8 Vdout1_8ck166 = 0.9 time = 835
.meas tran vdout1_8ck166 FIND v(dout1_8) AT=835.025n

* CHECK dout1_9 Vdout1_9ck166 = 0 time = 835
.meas tran vdout1_9ck166 FIND v(dout1_9) AT=835.025n

* CHECK dout1_10 Vdout1_10ck166 = 0 time = 835
.meas tran vdout1_10ck166 FIND v(dout1_10) AT=835.025n

* CHECK dout1_11 Vdout1_11ck166 = 0 time = 835
.meas tran vdout1_11ck166 FIND v(dout1_11) AT=835.025n

* CHECK dout1_12 Vdout1_12ck166 = 0 time = 835
.meas tran vdout1_12ck166 FIND v(dout1_12) AT=835.025n

* CHECK dout1_13 Vdout1_13ck166 = 0.9 time = 835
.meas tran vdout1_13ck166 FIND v(dout1_13) AT=835.025n

* CHECK dout1_14 Vdout1_14ck166 = 0 time = 835
.meas tran vdout1_14ck166 FIND v(dout1_14) AT=835.025n

* CHECK dout1_15 Vdout1_15ck166 = 0.9 time = 835
.meas tran vdout1_15ck166 FIND v(dout1_15) AT=835.025n

* CHECK dout1_16 Vdout1_16ck166 = 0.9 time = 835
.meas tran vdout1_16ck166 FIND v(dout1_16) AT=835.025n

* CHECK dout1_17 Vdout1_17ck166 = 0.9 time = 835
.meas tran vdout1_17ck166 FIND v(dout1_17) AT=835.025n

* CHECK dout1_18 Vdout1_18ck166 = 0.9 time = 835
.meas tran vdout1_18ck166 FIND v(dout1_18) AT=835.025n

* CHECK dout1_19 Vdout1_19ck166 = 0 time = 835
.meas tran vdout1_19ck166 FIND v(dout1_19) AT=835.025n

* CHECK dout1_20 Vdout1_20ck166 = 0.9 time = 835
.meas tran vdout1_20ck166 FIND v(dout1_20) AT=835.025n

* CHECK dout1_21 Vdout1_21ck166 = 0 time = 835
.meas tran vdout1_21ck166 FIND v(dout1_21) AT=835.025n

* CHECK dout1_22 Vdout1_22ck166 = 0 time = 835
.meas tran vdout1_22ck166 FIND v(dout1_22) AT=835.025n

* CHECK dout1_23 Vdout1_23ck166 = 0 time = 835
.meas tran vdout1_23ck166 FIND v(dout1_23) AT=835.025n

* CHECK dout1_24 Vdout1_24ck166 = 0.9 time = 835
.meas tran vdout1_24ck166 FIND v(dout1_24) AT=835.025n

* CHECK dout1_25 Vdout1_25ck166 = 0.9 time = 835
.meas tran vdout1_25ck166 FIND v(dout1_25) AT=835.025n

* CHECK dout1_26 Vdout1_26ck166 = 0 time = 835
.meas tran vdout1_26ck166 FIND v(dout1_26) AT=835.025n

* CHECK dout1_27 Vdout1_27ck166 = 0.9 time = 835
.meas tran vdout1_27ck166 FIND v(dout1_27) AT=835.025n

* CHECK dout1_28 Vdout1_28ck166 = 0 time = 835
.meas tran vdout1_28ck166 FIND v(dout1_28) AT=835.025n

* CHECK dout1_29 Vdout1_29ck166 = 0.9 time = 835
.meas tran vdout1_29ck166 FIND v(dout1_29) AT=835.025n

* CHECK dout1_30 Vdout1_30ck166 = 0 time = 835
.meas tran vdout1_30ck166 FIND v(dout1_30) AT=835.025n

* CHECK dout1_31 Vdout1_31ck166 = 0 time = 835
.meas tran vdout1_31ck166 FIND v(dout1_31) AT=835.025n

* CHECK dout1_32 Vdout1_32ck166 = 0 time = 835
.meas tran vdout1_32ck166 FIND v(dout1_32) AT=835.025n

* CHECK dout1_33 Vdout1_33ck166 = 0 time = 835
.meas tran vdout1_33ck166 FIND v(dout1_33) AT=835.025n

* CHECK dout1_34 Vdout1_34ck166 = 0.9 time = 835
.meas tran vdout1_34ck166 FIND v(dout1_34) AT=835.025n

* CHECK dout1_35 Vdout1_35ck166 = 0.9 time = 835
.meas tran vdout1_35ck166 FIND v(dout1_35) AT=835.025n

* CHECK dout1_36 Vdout1_36ck166 = 0.9 time = 835
.meas tran vdout1_36ck166 FIND v(dout1_36) AT=835.025n

* CHECK dout1_37 Vdout1_37ck166 = 0 time = 835
.meas tran vdout1_37ck166 FIND v(dout1_37) AT=835.025n

* CHECK dout1_38 Vdout1_38ck166 = 0.9 time = 835
.meas tran vdout1_38ck166 FIND v(dout1_38) AT=835.025n

* CHECK dout1_39 Vdout1_39ck166 = 0.9 time = 835
.meas tran vdout1_39ck166 FIND v(dout1_39) AT=835.025n

* CHECK dout1_40 Vdout1_40ck166 = 0.9 time = 835
.meas tran vdout1_40ck166 FIND v(dout1_40) AT=835.025n

* CHECK dout1_41 Vdout1_41ck166 = 0 time = 835
.meas tran vdout1_41ck166 FIND v(dout1_41) AT=835.025n

* CHECK dout1_42 Vdout1_42ck166 = 0.9 time = 835
.meas tran vdout1_42ck166 FIND v(dout1_42) AT=835.025n

* CHECK dout1_43 Vdout1_43ck166 = 0.9 time = 835
.meas tran vdout1_43ck166 FIND v(dout1_43) AT=835.025n

* CHECK dout1_44 Vdout1_44ck166 = 0.9 time = 835
.meas tran vdout1_44ck166 FIND v(dout1_44) AT=835.025n

* CHECK dout1_45 Vdout1_45ck166 = 0.9 time = 835
.meas tran vdout1_45ck166 FIND v(dout1_45) AT=835.025n

* CHECK dout1_46 Vdout1_46ck166 = 0.9 time = 835
.meas tran vdout1_46ck166 FIND v(dout1_46) AT=835.025n

* CHECK dout1_47 Vdout1_47ck166 = 0 time = 835
.meas tran vdout1_47ck166 FIND v(dout1_47) AT=835.025n

* CHECK dout1_48 Vdout1_48ck166 = 0.9 time = 835
.meas tran vdout1_48ck166 FIND v(dout1_48) AT=835.025n

* CHECK dout1_49 Vdout1_49ck166 = 0 time = 835
.meas tran vdout1_49ck166 FIND v(dout1_49) AT=835.025n

* CHECK dout1_50 Vdout1_50ck166 = 0 time = 835
.meas tran vdout1_50ck166 FIND v(dout1_50) AT=835.025n

* CHECK dout1_51 Vdout1_51ck166 = 0.9 time = 835
.meas tran vdout1_51ck166 FIND v(dout1_51) AT=835.025n

* CHECK dout1_52 Vdout1_52ck166 = 0.9 time = 835
.meas tran vdout1_52ck166 FIND v(dout1_52) AT=835.025n

* CHECK dout1_53 Vdout1_53ck166 = 0.9 time = 835
.meas tran vdout1_53ck166 FIND v(dout1_53) AT=835.025n

* CHECK dout1_54 Vdout1_54ck166 = 0.9 time = 835
.meas tran vdout1_54ck166 FIND v(dout1_54) AT=835.025n

* CHECK dout1_55 Vdout1_55ck166 = 0 time = 835
.meas tran vdout1_55ck166 FIND v(dout1_55) AT=835.025n

* CHECK dout1_56 Vdout1_56ck166 = 0.9 time = 835
.meas tran vdout1_56ck166 FIND v(dout1_56) AT=835.025n

* CHECK dout1_57 Vdout1_57ck166 = 0 time = 835
.meas tran vdout1_57ck166 FIND v(dout1_57) AT=835.025n

* CHECK dout1_58 Vdout1_58ck166 = 0.9 time = 835
.meas tran vdout1_58ck166 FIND v(dout1_58) AT=835.025n

* CHECK dout1_59 Vdout1_59ck166 = 0 time = 835
.meas tran vdout1_59ck166 FIND v(dout1_59) AT=835.025n

* CHECK dout1_60 Vdout1_60ck166 = 0 time = 835
.meas tran vdout1_60ck166 FIND v(dout1_60) AT=835.025n

* CHECK dout1_61 Vdout1_61ck166 = 0 time = 835
.meas tran vdout1_61ck166 FIND v(dout1_61) AT=835.025n

* CHECK dout1_62 Vdout1_62ck166 = 0 time = 835
.meas tran vdout1_62ck166 FIND v(dout1_62) AT=835.025n

* CHECK dout1_63 Vdout1_63ck166 = 0.9 time = 835
.meas tran vdout1_63ck166 FIND v(dout1_63) AT=835.025n

* CHECK dout1_64 Vdout1_64ck166 = 0 time = 835
.meas tran vdout1_64ck166 FIND v(dout1_64) AT=835.025n

* CHECK dout1_65 Vdout1_65ck166 = 0 time = 835
.meas tran vdout1_65ck166 FIND v(dout1_65) AT=835.025n

* CHECK dout1_66 Vdout1_66ck166 = 0.9 time = 835
.meas tran vdout1_66ck166 FIND v(dout1_66) AT=835.025n

* CHECK dout1_67 Vdout1_67ck166 = 0.9 time = 835
.meas tran vdout1_67ck166 FIND v(dout1_67) AT=835.025n

* CHECK dout1_68 Vdout1_68ck166 = 0.9 time = 835
.meas tran vdout1_68ck166 FIND v(dout1_68) AT=835.025n

* CHECK dout1_69 Vdout1_69ck166 = 0 time = 835
.meas tran vdout1_69ck166 FIND v(dout1_69) AT=835.025n

* CHECK dout1_70 Vdout1_70ck166 = 0.9 time = 835
.meas tran vdout1_70ck166 FIND v(dout1_70) AT=835.025n

* CHECK dout1_71 Vdout1_71ck166 = 0.9 time = 835
.meas tran vdout1_71ck166 FIND v(dout1_71) AT=835.025n

* CHECK dout1_72 Vdout1_72ck166 = 0.9 time = 835
.meas tran vdout1_72ck166 FIND v(dout1_72) AT=835.025n

* CHECK dout1_73 Vdout1_73ck166 = 0.9 time = 835
.meas tran vdout1_73ck166 FIND v(dout1_73) AT=835.025n

* CHECK dout1_74 Vdout1_74ck166 = 0.9 time = 835
.meas tran vdout1_74ck166 FIND v(dout1_74) AT=835.025n

* CHECK dout1_75 Vdout1_75ck166 = 0 time = 835
.meas tran vdout1_75ck166 FIND v(dout1_75) AT=835.025n

* CHECK dout1_76 Vdout1_76ck166 = 0.9 time = 835
.meas tran vdout1_76ck166 FIND v(dout1_76) AT=835.025n

* CHECK dout1_77 Vdout1_77ck166 = 0.9 time = 835
.meas tran vdout1_77ck166 FIND v(dout1_77) AT=835.025n

* CHECK dout1_78 Vdout1_78ck166 = 0.9 time = 835
.meas tran vdout1_78ck166 FIND v(dout1_78) AT=835.025n

* CHECK dout1_79 Vdout1_79ck166 = 0.9 time = 835
.meas tran vdout1_79ck166 FIND v(dout1_79) AT=835.025n

* CHECK dout1_80 Vdout1_80ck166 = 0 time = 835
.meas tran vdout1_80ck166 FIND v(dout1_80) AT=835.025n

* CHECK dout1_81 Vdout1_81ck166 = 0.9 time = 835
.meas tran vdout1_81ck166 FIND v(dout1_81) AT=835.025n

* CHECK dout1_82 Vdout1_82ck166 = 0 time = 835
.meas tran vdout1_82ck166 FIND v(dout1_82) AT=835.025n

* CHECK dout1_83 Vdout1_83ck166 = 0.9 time = 835
.meas tran vdout1_83ck166 FIND v(dout1_83) AT=835.025n

* CHECK dout1_84 Vdout1_84ck166 = 0 time = 835
.meas tran vdout1_84ck166 FIND v(dout1_84) AT=835.025n

* CHECK dout1_85 Vdout1_85ck166 = 0.9 time = 835
.meas tran vdout1_85ck166 FIND v(dout1_85) AT=835.025n

* CHECK dout1_86 Vdout1_86ck166 = 0.9 time = 835
.meas tran vdout1_86ck166 FIND v(dout1_86) AT=835.025n

* CHECK dout1_87 Vdout1_87ck166 = 0 time = 835
.meas tran vdout1_87ck166 FIND v(dout1_87) AT=835.025n

* CHECK dout1_88 Vdout1_88ck166 = 0 time = 835
.meas tran vdout1_88ck166 FIND v(dout1_88) AT=835.025n

* CHECK dout1_89 Vdout1_89ck166 = 0 time = 835
.meas tran vdout1_89ck166 FIND v(dout1_89) AT=835.025n

* CHECK dout1_90 Vdout1_90ck166 = 0 time = 835
.meas tran vdout1_90ck166 FIND v(dout1_90) AT=835.025n

* CHECK dout1_91 Vdout1_91ck166 = 0.9 time = 835
.meas tran vdout1_91ck166 FIND v(dout1_91) AT=835.025n

* CHECK dout1_92 Vdout1_92ck166 = 0 time = 835
.meas tran vdout1_92ck166 FIND v(dout1_92) AT=835.025n

* CHECK dout1_93 Vdout1_93ck166 = 0 time = 835
.meas tran vdout1_93ck166 FIND v(dout1_93) AT=835.025n

* CHECK dout1_94 Vdout1_94ck166 = 0.9 time = 835
.meas tran vdout1_94ck166 FIND v(dout1_94) AT=835.025n

* CHECK dout1_95 Vdout1_95ck166 = 0.9 time = 835
.meas tran vdout1_95ck166 FIND v(dout1_95) AT=835.025n

* CHECK dout1_96 Vdout1_96ck166 = 0.9 time = 835
.meas tran vdout1_96ck166 FIND v(dout1_96) AT=835.025n

* CHECK dout1_97 Vdout1_97ck166 = 0 time = 835
.meas tran vdout1_97ck166 FIND v(dout1_97) AT=835.025n

* CHECK dout1_98 Vdout1_98ck166 = 0 time = 835
.meas tran vdout1_98ck166 FIND v(dout1_98) AT=835.025n

* CHECK dout1_99 Vdout1_99ck166 = 0 time = 835
.meas tran vdout1_99ck166 FIND v(dout1_99) AT=835.025n

* CHECK dout1_100 Vdout1_100ck166 = 0.9 time = 835
.meas tran vdout1_100ck166 FIND v(dout1_100) AT=835.025n

* CHECK dout1_101 Vdout1_101ck166 = 0.9 time = 835
.meas tran vdout1_101ck166 FIND v(dout1_101) AT=835.025n

* CHECK dout1_102 Vdout1_102ck166 = 0 time = 835
.meas tran vdout1_102ck166 FIND v(dout1_102) AT=835.025n

* CHECK dout1_103 Vdout1_103ck166 = 0 time = 835
.meas tran vdout1_103ck166 FIND v(dout1_103) AT=835.025n

* CHECK dout1_104 Vdout1_104ck166 = 0.9 time = 835
.meas tran vdout1_104ck166 FIND v(dout1_104) AT=835.025n

* CHECK dout1_105 Vdout1_105ck166 = 0 time = 835
.meas tran vdout1_105ck166 FIND v(dout1_105) AT=835.025n

* CHECK dout1_106 Vdout1_106ck166 = 0 time = 835
.meas tran vdout1_106ck166 FIND v(dout1_106) AT=835.025n

* CHECK dout1_107 Vdout1_107ck166 = 0.9 time = 835
.meas tran vdout1_107ck166 FIND v(dout1_107) AT=835.025n

* CHECK dout1_108 Vdout1_108ck166 = 0 time = 835
.meas tran vdout1_108ck166 FIND v(dout1_108) AT=835.025n

* CHECK dout1_109 Vdout1_109ck166 = 0 time = 835
.meas tran vdout1_109ck166 FIND v(dout1_109) AT=835.025n

* CHECK dout1_110 Vdout1_110ck166 = 0.9 time = 835
.meas tran vdout1_110ck166 FIND v(dout1_110) AT=835.025n

* CHECK dout1_111 Vdout1_111ck166 = 0 time = 835
.meas tran vdout1_111ck166 FIND v(dout1_111) AT=835.025n

* CHECK dout1_112 Vdout1_112ck166 = 0.9 time = 835
.meas tran vdout1_112ck166 FIND v(dout1_112) AT=835.025n

* CHECK dout1_113 Vdout1_113ck166 = 0 time = 835
.meas tran vdout1_113ck166 FIND v(dout1_113) AT=835.025n

* CHECK dout1_114 Vdout1_114ck166 = 0 time = 835
.meas tran vdout1_114ck166 FIND v(dout1_114) AT=835.025n

* CHECK dout1_115 Vdout1_115ck166 = 0.9 time = 835
.meas tran vdout1_115ck166 FIND v(dout1_115) AT=835.025n

* CHECK dout1_116 Vdout1_116ck166 = 0.9 time = 835
.meas tran vdout1_116ck166 FIND v(dout1_116) AT=835.025n

* CHECK dout1_117 Vdout1_117ck166 = 0.9 time = 835
.meas tran vdout1_117ck166 FIND v(dout1_117) AT=835.025n

* CHECK dout1_118 Vdout1_118ck166 = 0.9 time = 835
.meas tran vdout1_118ck166 FIND v(dout1_118) AT=835.025n

* CHECK dout1_119 Vdout1_119ck166 = 0.9 time = 835
.meas tran vdout1_119ck166 FIND v(dout1_119) AT=835.025n

* CHECK dout1_0 Vdout1_0ck170 = 0 time = 855
.meas tran vdout1_0ck170 FIND v(dout1_0) AT=855.025n

* CHECK dout1_1 Vdout1_1ck170 = 0.9 time = 855
.meas tran vdout1_1ck170 FIND v(dout1_1) AT=855.025n

* CHECK dout1_2 Vdout1_2ck170 = 0.9 time = 855
.meas tran vdout1_2ck170 FIND v(dout1_2) AT=855.025n

* CHECK dout1_3 Vdout1_3ck170 = 0.9 time = 855
.meas tran vdout1_3ck170 FIND v(dout1_3) AT=855.025n

* CHECK dout1_4 Vdout1_4ck170 = 0 time = 855
.meas tran vdout1_4ck170 FIND v(dout1_4) AT=855.025n

* CHECK dout1_5 Vdout1_5ck170 = 0.9 time = 855
.meas tran vdout1_5ck170 FIND v(dout1_5) AT=855.025n

* CHECK dout1_6 Vdout1_6ck170 = 0 time = 855
.meas tran vdout1_6ck170 FIND v(dout1_6) AT=855.025n

* CHECK dout1_7 Vdout1_7ck170 = 0 time = 855
.meas tran vdout1_7ck170 FIND v(dout1_7) AT=855.025n

* CHECK dout1_8 Vdout1_8ck170 = 0.9 time = 855
.meas tran vdout1_8ck170 FIND v(dout1_8) AT=855.025n

* CHECK dout1_9 Vdout1_9ck170 = 0.9 time = 855
.meas tran vdout1_9ck170 FIND v(dout1_9) AT=855.025n

* CHECK dout1_10 Vdout1_10ck170 = 0.9 time = 855
.meas tran vdout1_10ck170 FIND v(dout1_10) AT=855.025n

* CHECK dout1_11 Vdout1_11ck170 = 0.9 time = 855
.meas tran vdout1_11ck170 FIND v(dout1_11) AT=855.025n

* CHECK dout1_12 Vdout1_12ck170 = 0.9 time = 855
.meas tran vdout1_12ck170 FIND v(dout1_12) AT=855.025n

* CHECK dout1_13 Vdout1_13ck170 = 0.9 time = 855
.meas tran vdout1_13ck170 FIND v(dout1_13) AT=855.025n

* CHECK dout1_14 Vdout1_14ck170 = 0 time = 855
.meas tran vdout1_14ck170 FIND v(dout1_14) AT=855.025n

* CHECK dout1_15 Vdout1_15ck170 = 0.9 time = 855
.meas tran vdout1_15ck170 FIND v(dout1_15) AT=855.025n

* CHECK dout1_16 Vdout1_16ck170 = 0 time = 855
.meas tran vdout1_16ck170 FIND v(dout1_16) AT=855.025n

* CHECK dout1_17 Vdout1_17ck170 = 0.9 time = 855
.meas tran vdout1_17ck170 FIND v(dout1_17) AT=855.025n

* CHECK dout1_18 Vdout1_18ck170 = 0 time = 855
.meas tran vdout1_18ck170 FIND v(dout1_18) AT=855.025n

* CHECK dout1_19 Vdout1_19ck170 = 0.9 time = 855
.meas tran vdout1_19ck170 FIND v(dout1_19) AT=855.025n

* CHECK dout1_20 Vdout1_20ck170 = 0.9 time = 855
.meas tran vdout1_20ck170 FIND v(dout1_20) AT=855.025n

* CHECK dout1_21 Vdout1_21ck170 = 0 time = 855
.meas tran vdout1_21ck170 FIND v(dout1_21) AT=855.025n

* CHECK dout1_22 Vdout1_22ck170 = 0.9 time = 855
.meas tran vdout1_22ck170 FIND v(dout1_22) AT=855.025n

* CHECK dout1_23 Vdout1_23ck170 = 0.9 time = 855
.meas tran vdout1_23ck170 FIND v(dout1_23) AT=855.025n

* CHECK dout1_24 Vdout1_24ck170 = 0.9 time = 855
.meas tran vdout1_24ck170 FIND v(dout1_24) AT=855.025n

* CHECK dout1_25 Vdout1_25ck170 = 0 time = 855
.meas tran vdout1_25ck170 FIND v(dout1_25) AT=855.025n

* CHECK dout1_26 Vdout1_26ck170 = 0 time = 855
.meas tran vdout1_26ck170 FIND v(dout1_26) AT=855.025n

* CHECK dout1_27 Vdout1_27ck170 = 0.9 time = 855
.meas tran vdout1_27ck170 FIND v(dout1_27) AT=855.025n

* CHECK dout1_28 Vdout1_28ck170 = 0.9 time = 855
.meas tran vdout1_28ck170 FIND v(dout1_28) AT=855.025n

* CHECK dout1_29 Vdout1_29ck170 = 0 time = 855
.meas tran vdout1_29ck170 FIND v(dout1_29) AT=855.025n

* CHECK dout1_30 Vdout1_30ck170 = 0 time = 855
.meas tran vdout1_30ck170 FIND v(dout1_30) AT=855.025n

* CHECK dout1_31 Vdout1_31ck170 = 0 time = 855
.meas tran vdout1_31ck170 FIND v(dout1_31) AT=855.025n

* CHECK dout1_32 Vdout1_32ck170 = 0 time = 855
.meas tran vdout1_32ck170 FIND v(dout1_32) AT=855.025n

* CHECK dout1_33 Vdout1_33ck170 = 0.9 time = 855
.meas tran vdout1_33ck170 FIND v(dout1_33) AT=855.025n

* CHECK dout1_34 Vdout1_34ck170 = 0 time = 855
.meas tran vdout1_34ck170 FIND v(dout1_34) AT=855.025n

* CHECK dout1_35 Vdout1_35ck170 = 0.9 time = 855
.meas tran vdout1_35ck170 FIND v(dout1_35) AT=855.025n

* CHECK dout1_36 Vdout1_36ck170 = 0 time = 855
.meas tran vdout1_36ck170 FIND v(dout1_36) AT=855.025n

* CHECK dout1_37 Vdout1_37ck170 = 0 time = 855
.meas tran vdout1_37ck170 FIND v(dout1_37) AT=855.025n

* CHECK dout1_38 Vdout1_38ck170 = 0 time = 855
.meas tran vdout1_38ck170 FIND v(dout1_38) AT=855.025n

* CHECK dout1_39 Vdout1_39ck170 = 0.9 time = 855
.meas tran vdout1_39ck170 FIND v(dout1_39) AT=855.025n

* CHECK dout1_40 Vdout1_40ck170 = 0 time = 855
.meas tran vdout1_40ck170 FIND v(dout1_40) AT=855.025n

* CHECK dout1_41 Vdout1_41ck170 = 0.9 time = 855
.meas tran vdout1_41ck170 FIND v(dout1_41) AT=855.025n

* CHECK dout1_42 Vdout1_42ck170 = 0 time = 855
.meas tran vdout1_42ck170 FIND v(dout1_42) AT=855.025n

* CHECK dout1_43 Vdout1_43ck170 = 0 time = 855
.meas tran vdout1_43ck170 FIND v(dout1_43) AT=855.025n

* CHECK dout1_44 Vdout1_44ck170 = 0.9 time = 855
.meas tran vdout1_44ck170 FIND v(dout1_44) AT=855.025n

* CHECK dout1_45 Vdout1_45ck170 = 0 time = 855
.meas tran vdout1_45ck170 FIND v(dout1_45) AT=855.025n

* CHECK dout1_46 Vdout1_46ck170 = 0.9 time = 855
.meas tran vdout1_46ck170 FIND v(dout1_46) AT=855.025n

* CHECK dout1_47 Vdout1_47ck170 = 0.9 time = 855
.meas tran vdout1_47ck170 FIND v(dout1_47) AT=855.025n

* CHECK dout1_48 Vdout1_48ck170 = 0.9 time = 855
.meas tran vdout1_48ck170 FIND v(dout1_48) AT=855.025n

* CHECK dout1_49 Vdout1_49ck170 = 0.9 time = 855
.meas tran vdout1_49ck170 FIND v(dout1_49) AT=855.025n

* CHECK dout1_50 Vdout1_50ck170 = 0 time = 855
.meas tran vdout1_50ck170 FIND v(dout1_50) AT=855.025n

* CHECK dout1_51 Vdout1_51ck170 = 0 time = 855
.meas tran vdout1_51ck170 FIND v(dout1_51) AT=855.025n

* CHECK dout1_52 Vdout1_52ck170 = 0.9 time = 855
.meas tran vdout1_52ck170 FIND v(dout1_52) AT=855.025n

* CHECK dout1_53 Vdout1_53ck170 = 0 time = 855
.meas tran vdout1_53ck170 FIND v(dout1_53) AT=855.025n

* CHECK dout1_54 Vdout1_54ck170 = 0.9 time = 855
.meas tran vdout1_54ck170 FIND v(dout1_54) AT=855.025n

* CHECK dout1_55 Vdout1_55ck170 = 0 time = 855
.meas tran vdout1_55ck170 FIND v(dout1_55) AT=855.025n

* CHECK dout1_56 Vdout1_56ck170 = 0.9 time = 855
.meas tran vdout1_56ck170 FIND v(dout1_56) AT=855.025n

* CHECK dout1_57 Vdout1_57ck170 = 0.9 time = 855
.meas tran vdout1_57ck170 FIND v(dout1_57) AT=855.025n

* CHECK dout1_58 Vdout1_58ck170 = 0 time = 855
.meas tran vdout1_58ck170 FIND v(dout1_58) AT=855.025n

* CHECK dout1_59 Vdout1_59ck170 = 0 time = 855
.meas tran vdout1_59ck170 FIND v(dout1_59) AT=855.025n

* CHECK dout1_60 Vdout1_60ck170 = 0.9 time = 855
.meas tran vdout1_60ck170 FIND v(dout1_60) AT=855.025n

* CHECK dout1_61 Vdout1_61ck170 = 0 time = 855
.meas tran vdout1_61ck170 FIND v(dout1_61) AT=855.025n

* CHECK dout1_62 Vdout1_62ck170 = 0.9 time = 855
.meas tran vdout1_62ck170 FIND v(dout1_62) AT=855.025n

* CHECK dout1_63 Vdout1_63ck170 = 0.9 time = 855
.meas tran vdout1_63ck170 FIND v(dout1_63) AT=855.025n

* CHECK dout1_64 Vdout1_64ck170 = 0 time = 855
.meas tran vdout1_64ck170 FIND v(dout1_64) AT=855.025n

* CHECK dout1_65 Vdout1_65ck170 = 0.9 time = 855
.meas tran vdout1_65ck170 FIND v(dout1_65) AT=855.025n

* CHECK dout1_66 Vdout1_66ck170 = 0.9 time = 855
.meas tran vdout1_66ck170 FIND v(dout1_66) AT=855.025n

* CHECK dout1_67 Vdout1_67ck170 = 0 time = 855
.meas tran vdout1_67ck170 FIND v(dout1_67) AT=855.025n

* CHECK dout1_68 Vdout1_68ck170 = 0.9 time = 855
.meas tran vdout1_68ck170 FIND v(dout1_68) AT=855.025n

* CHECK dout1_69 Vdout1_69ck170 = 0 time = 855
.meas tran vdout1_69ck170 FIND v(dout1_69) AT=855.025n

* CHECK dout1_70 Vdout1_70ck170 = 0.9 time = 855
.meas tran vdout1_70ck170 FIND v(dout1_70) AT=855.025n

* CHECK dout1_71 Vdout1_71ck170 = 0 time = 855
.meas tran vdout1_71ck170 FIND v(dout1_71) AT=855.025n

* CHECK dout1_72 Vdout1_72ck170 = 0 time = 855
.meas tran vdout1_72ck170 FIND v(dout1_72) AT=855.025n

* CHECK dout1_73 Vdout1_73ck170 = 0 time = 855
.meas tran vdout1_73ck170 FIND v(dout1_73) AT=855.025n

* CHECK dout1_74 Vdout1_74ck170 = 0 time = 855
.meas tran vdout1_74ck170 FIND v(dout1_74) AT=855.025n

* CHECK dout1_75 Vdout1_75ck170 = 0.9 time = 855
.meas tran vdout1_75ck170 FIND v(dout1_75) AT=855.025n

* CHECK dout1_76 Vdout1_76ck170 = 0.9 time = 855
.meas tran vdout1_76ck170 FIND v(dout1_76) AT=855.025n

* CHECK dout1_77 Vdout1_77ck170 = 0 time = 855
.meas tran vdout1_77ck170 FIND v(dout1_77) AT=855.025n

* CHECK dout1_78 Vdout1_78ck170 = 0 time = 855
.meas tran vdout1_78ck170 FIND v(dout1_78) AT=855.025n

* CHECK dout1_79 Vdout1_79ck170 = 0 time = 855
.meas tran vdout1_79ck170 FIND v(dout1_79) AT=855.025n

* CHECK dout1_80 Vdout1_80ck170 = 0 time = 855
.meas tran vdout1_80ck170 FIND v(dout1_80) AT=855.025n

* CHECK dout1_81 Vdout1_81ck170 = 0.9 time = 855
.meas tran vdout1_81ck170 FIND v(dout1_81) AT=855.025n

* CHECK dout1_82 Vdout1_82ck170 = 0 time = 855
.meas tran vdout1_82ck170 FIND v(dout1_82) AT=855.025n

* CHECK dout1_83 Vdout1_83ck170 = 0.9 time = 855
.meas tran vdout1_83ck170 FIND v(dout1_83) AT=855.025n

* CHECK dout1_84 Vdout1_84ck170 = 0.9 time = 855
.meas tran vdout1_84ck170 FIND v(dout1_84) AT=855.025n

* CHECK dout1_85 Vdout1_85ck170 = 0.9 time = 855
.meas tran vdout1_85ck170 FIND v(dout1_85) AT=855.025n

* CHECK dout1_86 Vdout1_86ck170 = 0.9 time = 855
.meas tran vdout1_86ck170 FIND v(dout1_86) AT=855.025n

* CHECK dout1_87 Vdout1_87ck170 = 0 time = 855
.meas tran vdout1_87ck170 FIND v(dout1_87) AT=855.025n

* CHECK dout1_88 Vdout1_88ck170 = 0 time = 855
.meas tran vdout1_88ck170 FIND v(dout1_88) AT=855.025n

* CHECK dout1_89 Vdout1_89ck170 = 0 time = 855
.meas tran vdout1_89ck170 FIND v(dout1_89) AT=855.025n

* CHECK dout1_90 Vdout1_90ck170 = 0 time = 855
.meas tran vdout1_90ck170 FIND v(dout1_90) AT=855.025n

* CHECK dout1_91 Vdout1_91ck170 = 0.9 time = 855
.meas tran vdout1_91ck170 FIND v(dout1_91) AT=855.025n

* CHECK dout1_92 Vdout1_92ck170 = 0.9 time = 855
.meas tran vdout1_92ck170 FIND v(dout1_92) AT=855.025n

* CHECK dout1_93 Vdout1_93ck170 = 0.9 time = 855
.meas tran vdout1_93ck170 FIND v(dout1_93) AT=855.025n

* CHECK dout1_94 Vdout1_94ck170 = 0 time = 855
.meas tran vdout1_94ck170 FIND v(dout1_94) AT=855.025n

* CHECK dout1_95 Vdout1_95ck170 = 0.9 time = 855
.meas tran vdout1_95ck170 FIND v(dout1_95) AT=855.025n

* CHECK dout1_96 Vdout1_96ck170 = 0 time = 855
.meas tran vdout1_96ck170 FIND v(dout1_96) AT=855.025n

* CHECK dout1_97 Vdout1_97ck170 = 0 time = 855
.meas tran vdout1_97ck170 FIND v(dout1_97) AT=855.025n

* CHECK dout1_98 Vdout1_98ck170 = 0.9 time = 855
.meas tran vdout1_98ck170 FIND v(dout1_98) AT=855.025n

* CHECK dout1_99 Vdout1_99ck170 = 0 time = 855
.meas tran vdout1_99ck170 FIND v(dout1_99) AT=855.025n

* CHECK dout1_100 Vdout1_100ck170 = 0 time = 855
.meas tran vdout1_100ck170 FIND v(dout1_100) AT=855.025n

* CHECK dout1_101 Vdout1_101ck170 = 0.9 time = 855
.meas tran vdout1_101ck170 FIND v(dout1_101) AT=855.025n

* CHECK dout1_102 Vdout1_102ck170 = 0.9 time = 855
.meas tran vdout1_102ck170 FIND v(dout1_102) AT=855.025n

* CHECK dout1_103 Vdout1_103ck170 = 0.9 time = 855
.meas tran vdout1_103ck170 FIND v(dout1_103) AT=855.025n

* CHECK dout1_104 Vdout1_104ck170 = 0.9 time = 855
.meas tran vdout1_104ck170 FIND v(dout1_104) AT=855.025n

* CHECK dout1_105 Vdout1_105ck170 = 0 time = 855
.meas tran vdout1_105ck170 FIND v(dout1_105) AT=855.025n

* CHECK dout1_106 Vdout1_106ck170 = 0 time = 855
.meas tran vdout1_106ck170 FIND v(dout1_106) AT=855.025n

* CHECK dout1_107 Vdout1_107ck170 = 0.9 time = 855
.meas tran vdout1_107ck170 FIND v(dout1_107) AT=855.025n

* CHECK dout1_108 Vdout1_108ck170 = 0 time = 855
.meas tran vdout1_108ck170 FIND v(dout1_108) AT=855.025n

* CHECK dout1_109 Vdout1_109ck170 = 0.9 time = 855
.meas tran vdout1_109ck170 FIND v(dout1_109) AT=855.025n

* CHECK dout1_110 Vdout1_110ck170 = 0.9 time = 855
.meas tran vdout1_110ck170 FIND v(dout1_110) AT=855.025n

* CHECK dout1_111 Vdout1_111ck170 = 0 time = 855
.meas tran vdout1_111ck170 FIND v(dout1_111) AT=855.025n

* CHECK dout1_112 Vdout1_112ck170 = 0.9 time = 855
.meas tran vdout1_112ck170 FIND v(dout1_112) AT=855.025n

* CHECK dout1_113 Vdout1_113ck170 = 0 time = 855
.meas tran vdout1_113ck170 FIND v(dout1_113) AT=855.025n

* CHECK dout1_114 Vdout1_114ck170 = 0.9 time = 855
.meas tran vdout1_114ck170 FIND v(dout1_114) AT=855.025n

* CHECK dout1_115 Vdout1_115ck170 = 0.9 time = 855
.meas tran vdout1_115ck170 FIND v(dout1_115) AT=855.025n

* CHECK dout1_116 Vdout1_116ck170 = 0 time = 855
.meas tran vdout1_116ck170 FIND v(dout1_116) AT=855.025n

* CHECK dout1_117 Vdout1_117ck170 = 0 time = 855
.meas tran vdout1_117ck170 FIND v(dout1_117) AT=855.025n

* CHECK dout1_118 Vdout1_118ck170 = 0.9 time = 855
.meas tran vdout1_118ck170 FIND v(dout1_118) AT=855.025n

* CHECK dout1_119 Vdout1_119ck170 = 0.9 time = 855
.meas tran vdout1_119ck170 FIND v(dout1_119) AT=855.025n

* CHECK dout1_0 Vdout1_0ck171 = 0 time = 860
.meas tran vdout1_0ck171 FIND v(dout1_0) AT=860.025n

* CHECK dout1_1 Vdout1_1ck171 = 0.9 time = 860
.meas tran vdout1_1ck171 FIND v(dout1_1) AT=860.025n

* CHECK dout1_2 Vdout1_2ck171 = 0.9 time = 860
.meas tran vdout1_2ck171 FIND v(dout1_2) AT=860.025n

* CHECK dout1_3 Vdout1_3ck171 = 0.9 time = 860
.meas tran vdout1_3ck171 FIND v(dout1_3) AT=860.025n

* CHECK dout1_4 Vdout1_4ck171 = 0 time = 860
.meas tran vdout1_4ck171 FIND v(dout1_4) AT=860.025n

* CHECK dout1_5 Vdout1_5ck171 = 0.9 time = 860
.meas tran vdout1_5ck171 FIND v(dout1_5) AT=860.025n

* CHECK dout1_6 Vdout1_6ck171 = 0 time = 860
.meas tran vdout1_6ck171 FIND v(dout1_6) AT=860.025n

* CHECK dout1_7 Vdout1_7ck171 = 0 time = 860
.meas tran vdout1_7ck171 FIND v(dout1_7) AT=860.025n

* CHECK dout1_8 Vdout1_8ck171 = 0.9 time = 860
.meas tran vdout1_8ck171 FIND v(dout1_8) AT=860.025n

* CHECK dout1_9 Vdout1_9ck171 = 0.9 time = 860
.meas tran vdout1_9ck171 FIND v(dout1_9) AT=860.025n

* CHECK dout1_10 Vdout1_10ck171 = 0.9 time = 860
.meas tran vdout1_10ck171 FIND v(dout1_10) AT=860.025n

* CHECK dout1_11 Vdout1_11ck171 = 0.9 time = 860
.meas tran vdout1_11ck171 FIND v(dout1_11) AT=860.025n

* CHECK dout1_12 Vdout1_12ck171 = 0.9 time = 860
.meas tran vdout1_12ck171 FIND v(dout1_12) AT=860.025n

* CHECK dout1_13 Vdout1_13ck171 = 0.9 time = 860
.meas tran vdout1_13ck171 FIND v(dout1_13) AT=860.025n

* CHECK dout1_14 Vdout1_14ck171 = 0 time = 860
.meas tran vdout1_14ck171 FIND v(dout1_14) AT=860.025n

* CHECK dout1_15 Vdout1_15ck171 = 0.9 time = 860
.meas tran vdout1_15ck171 FIND v(dout1_15) AT=860.025n

* CHECK dout1_16 Vdout1_16ck171 = 0 time = 860
.meas tran vdout1_16ck171 FIND v(dout1_16) AT=860.025n

* CHECK dout1_17 Vdout1_17ck171 = 0.9 time = 860
.meas tran vdout1_17ck171 FIND v(dout1_17) AT=860.025n

* CHECK dout1_18 Vdout1_18ck171 = 0 time = 860
.meas tran vdout1_18ck171 FIND v(dout1_18) AT=860.025n

* CHECK dout1_19 Vdout1_19ck171 = 0.9 time = 860
.meas tran vdout1_19ck171 FIND v(dout1_19) AT=860.025n

* CHECK dout1_20 Vdout1_20ck171 = 0.9 time = 860
.meas tran vdout1_20ck171 FIND v(dout1_20) AT=860.025n

* CHECK dout1_21 Vdout1_21ck171 = 0 time = 860
.meas tran vdout1_21ck171 FIND v(dout1_21) AT=860.025n

* CHECK dout1_22 Vdout1_22ck171 = 0.9 time = 860
.meas tran vdout1_22ck171 FIND v(dout1_22) AT=860.025n

* CHECK dout1_23 Vdout1_23ck171 = 0.9 time = 860
.meas tran vdout1_23ck171 FIND v(dout1_23) AT=860.025n

* CHECK dout1_24 Vdout1_24ck171 = 0.9 time = 860
.meas tran vdout1_24ck171 FIND v(dout1_24) AT=860.025n

* CHECK dout1_25 Vdout1_25ck171 = 0 time = 860
.meas tran vdout1_25ck171 FIND v(dout1_25) AT=860.025n

* CHECK dout1_26 Vdout1_26ck171 = 0 time = 860
.meas tran vdout1_26ck171 FIND v(dout1_26) AT=860.025n

* CHECK dout1_27 Vdout1_27ck171 = 0.9 time = 860
.meas tran vdout1_27ck171 FIND v(dout1_27) AT=860.025n

* CHECK dout1_28 Vdout1_28ck171 = 0.9 time = 860
.meas tran vdout1_28ck171 FIND v(dout1_28) AT=860.025n

* CHECK dout1_29 Vdout1_29ck171 = 0 time = 860
.meas tran vdout1_29ck171 FIND v(dout1_29) AT=860.025n

* CHECK dout1_30 Vdout1_30ck171 = 0 time = 860
.meas tran vdout1_30ck171 FIND v(dout1_30) AT=860.025n

* CHECK dout1_31 Vdout1_31ck171 = 0 time = 860
.meas tran vdout1_31ck171 FIND v(dout1_31) AT=860.025n

* CHECK dout1_32 Vdout1_32ck171 = 0 time = 860
.meas tran vdout1_32ck171 FIND v(dout1_32) AT=860.025n

* CHECK dout1_33 Vdout1_33ck171 = 0.9 time = 860
.meas tran vdout1_33ck171 FIND v(dout1_33) AT=860.025n

* CHECK dout1_34 Vdout1_34ck171 = 0 time = 860
.meas tran vdout1_34ck171 FIND v(dout1_34) AT=860.025n

* CHECK dout1_35 Vdout1_35ck171 = 0.9 time = 860
.meas tran vdout1_35ck171 FIND v(dout1_35) AT=860.025n

* CHECK dout1_36 Vdout1_36ck171 = 0 time = 860
.meas tran vdout1_36ck171 FIND v(dout1_36) AT=860.025n

* CHECK dout1_37 Vdout1_37ck171 = 0 time = 860
.meas tran vdout1_37ck171 FIND v(dout1_37) AT=860.025n

* CHECK dout1_38 Vdout1_38ck171 = 0 time = 860
.meas tran vdout1_38ck171 FIND v(dout1_38) AT=860.025n

* CHECK dout1_39 Vdout1_39ck171 = 0.9 time = 860
.meas tran vdout1_39ck171 FIND v(dout1_39) AT=860.025n

* CHECK dout1_40 Vdout1_40ck171 = 0 time = 860
.meas tran vdout1_40ck171 FIND v(dout1_40) AT=860.025n

* CHECK dout1_41 Vdout1_41ck171 = 0.9 time = 860
.meas tran vdout1_41ck171 FIND v(dout1_41) AT=860.025n

* CHECK dout1_42 Vdout1_42ck171 = 0 time = 860
.meas tran vdout1_42ck171 FIND v(dout1_42) AT=860.025n

* CHECK dout1_43 Vdout1_43ck171 = 0 time = 860
.meas tran vdout1_43ck171 FIND v(dout1_43) AT=860.025n

* CHECK dout1_44 Vdout1_44ck171 = 0.9 time = 860
.meas tran vdout1_44ck171 FIND v(dout1_44) AT=860.025n

* CHECK dout1_45 Vdout1_45ck171 = 0 time = 860
.meas tran vdout1_45ck171 FIND v(dout1_45) AT=860.025n

* CHECK dout1_46 Vdout1_46ck171 = 0.9 time = 860
.meas tran vdout1_46ck171 FIND v(dout1_46) AT=860.025n

* CHECK dout1_47 Vdout1_47ck171 = 0.9 time = 860
.meas tran vdout1_47ck171 FIND v(dout1_47) AT=860.025n

* CHECK dout1_48 Vdout1_48ck171 = 0.9 time = 860
.meas tran vdout1_48ck171 FIND v(dout1_48) AT=860.025n

* CHECK dout1_49 Vdout1_49ck171 = 0.9 time = 860
.meas tran vdout1_49ck171 FIND v(dout1_49) AT=860.025n

* CHECK dout1_50 Vdout1_50ck171 = 0 time = 860
.meas tran vdout1_50ck171 FIND v(dout1_50) AT=860.025n

* CHECK dout1_51 Vdout1_51ck171 = 0 time = 860
.meas tran vdout1_51ck171 FIND v(dout1_51) AT=860.025n

* CHECK dout1_52 Vdout1_52ck171 = 0.9 time = 860
.meas tran vdout1_52ck171 FIND v(dout1_52) AT=860.025n

* CHECK dout1_53 Vdout1_53ck171 = 0 time = 860
.meas tran vdout1_53ck171 FIND v(dout1_53) AT=860.025n

* CHECK dout1_54 Vdout1_54ck171 = 0.9 time = 860
.meas tran vdout1_54ck171 FIND v(dout1_54) AT=860.025n

* CHECK dout1_55 Vdout1_55ck171 = 0 time = 860
.meas tran vdout1_55ck171 FIND v(dout1_55) AT=860.025n

* CHECK dout1_56 Vdout1_56ck171 = 0.9 time = 860
.meas tran vdout1_56ck171 FIND v(dout1_56) AT=860.025n

* CHECK dout1_57 Vdout1_57ck171 = 0.9 time = 860
.meas tran vdout1_57ck171 FIND v(dout1_57) AT=860.025n

* CHECK dout1_58 Vdout1_58ck171 = 0 time = 860
.meas tran vdout1_58ck171 FIND v(dout1_58) AT=860.025n

* CHECK dout1_59 Vdout1_59ck171 = 0 time = 860
.meas tran vdout1_59ck171 FIND v(dout1_59) AT=860.025n

* CHECK dout1_60 Vdout1_60ck171 = 0.9 time = 860
.meas tran vdout1_60ck171 FIND v(dout1_60) AT=860.025n

* CHECK dout1_61 Vdout1_61ck171 = 0 time = 860
.meas tran vdout1_61ck171 FIND v(dout1_61) AT=860.025n

* CHECK dout1_62 Vdout1_62ck171 = 0.9 time = 860
.meas tran vdout1_62ck171 FIND v(dout1_62) AT=860.025n

* CHECK dout1_63 Vdout1_63ck171 = 0.9 time = 860
.meas tran vdout1_63ck171 FIND v(dout1_63) AT=860.025n

* CHECK dout1_64 Vdout1_64ck171 = 0 time = 860
.meas tran vdout1_64ck171 FIND v(dout1_64) AT=860.025n

* CHECK dout1_65 Vdout1_65ck171 = 0.9 time = 860
.meas tran vdout1_65ck171 FIND v(dout1_65) AT=860.025n

* CHECK dout1_66 Vdout1_66ck171 = 0.9 time = 860
.meas tran vdout1_66ck171 FIND v(dout1_66) AT=860.025n

* CHECK dout1_67 Vdout1_67ck171 = 0 time = 860
.meas tran vdout1_67ck171 FIND v(dout1_67) AT=860.025n

* CHECK dout1_68 Vdout1_68ck171 = 0.9 time = 860
.meas tran vdout1_68ck171 FIND v(dout1_68) AT=860.025n

* CHECK dout1_69 Vdout1_69ck171 = 0 time = 860
.meas tran vdout1_69ck171 FIND v(dout1_69) AT=860.025n

* CHECK dout1_70 Vdout1_70ck171 = 0.9 time = 860
.meas tran vdout1_70ck171 FIND v(dout1_70) AT=860.025n

* CHECK dout1_71 Vdout1_71ck171 = 0 time = 860
.meas tran vdout1_71ck171 FIND v(dout1_71) AT=860.025n

* CHECK dout1_72 Vdout1_72ck171 = 0 time = 860
.meas tran vdout1_72ck171 FIND v(dout1_72) AT=860.025n

* CHECK dout1_73 Vdout1_73ck171 = 0 time = 860
.meas tran vdout1_73ck171 FIND v(dout1_73) AT=860.025n

* CHECK dout1_74 Vdout1_74ck171 = 0 time = 860
.meas tran vdout1_74ck171 FIND v(dout1_74) AT=860.025n

* CHECK dout1_75 Vdout1_75ck171 = 0.9 time = 860
.meas tran vdout1_75ck171 FIND v(dout1_75) AT=860.025n

* CHECK dout1_76 Vdout1_76ck171 = 0.9 time = 860
.meas tran vdout1_76ck171 FIND v(dout1_76) AT=860.025n

* CHECK dout1_77 Vdout1_77ck171 = 0 time = 860
.meas tran vdout1_77ck171 FIND v(dout1_77) AT=860.025n

* CHECK dout1_78 Vdout1_78ck171 = 0 time = 860
.meas tran vdout1_78ck171 FIND v(dout1_78) AT=860.025n

* CHECK dout1_79 Vdout1_79ck171 = 0 time = 860
.meas tran vdout1_79ck171 FIND v(dout1_79) AT=860.025n

* CHECK dout1_80 Vdout1_80ck171 = 0 time = 860
.meas tran vdout1_80ck171 FIND v(dout1_80) AT=860.025n

* CHECK dout1_81 Vdout1_81ck171 = 0.9 time = 860
.meas tran vdout1_81ck171 FIND v(dout1_81) AT=860.025n

* CHECK dout1_82 Vdout1_82ck171 = 0 time = 860
.meas tran vdout1_82ck171 FIND v(dout1_82) AT=860.025n

* CHECK dout1_83 Vdout1_83ck171 = 0.9 time = 860
.meas tran vdout1_83ck171 FIND v(dout1_83) AT=860.025n

* CHECK dout1_84 Vdout1_84ck171 = 0.9 time = 860
.meas tran vdout1_84ck171 FIND v(dout1_84) AT=860.025n

* CHECK dout1_85 Vdout1_85ck171 = 0.9 time = 860
.meas tran vdout1_85ck171 FIND v(dout1_85) AT=860.025n

* CHECK dout1_86 Vdout1_86ck171 = 0.9 time = 860
.meas tran vdout1_86ck171 FIND v(dout1_86) AT=860.025n

* CHECK dout1_87 Vdout1_87ck171 = 0 time = 860
.meas tran vdout1_87ck171 FIND v(dout1_87) AT=860.025n

* CHECK dout1_88 Vdout1_88ck171 = 0 time = 860
.meas tran vdout1_88ck171 FIND v(dout1_88) AT=860.025n

* CHECK dout1_89 Vdout1_89ck171 = 0 time = 860
.meas tran vdout1_89ck171 FIND v(dout1_89) AT=860.025n

* CHECK dout1_90 Vdout1_90ck171 = 0 time = 860
.meas tran vdout1_90ck171 FIND v(dout1_90) AT=860.025n

* CHECK dout1_91 Vdout1_91ck171 = 0.9 time = 860
.meas tran vdout1_91ck171 FIND v(dout1_91) AT=860.025n

* CHECK dout1_92 Vdout1_92ck171 = 0.9 time = 860
.meas tran vdout1_92ck171 FIND v(dout1_92) AT=860.025n

* CHECK dout1_93 Vdout1_93ck171 = 0.9 time = 860
.meas tran vdout1_93ck171 FIND v(dout1_93) AT=860.025n

* CHECK dout1_94 Vdout1_94ck171 = 0 time = 860
.meas tran vdout1_94ck171 FIND v(dout1_94) AT=860.025n

* CHECK dout1_95 Vdout1_95ck171 = 0.9 time = 860
.meas tran vdout1_95ck171 FIND v(dout1_95) AT=860.025n

* CHECK dout1_96 Vdout1_96ck171 = 0 time = 860
.meas tran vdout1_96ck171 FIND v(dout1_96) AT=860.025n

* CHECK dout1_97 Vdout1_97ck171 = 0 time = 860
.meas tran vdout1_97ck171 FIND v(dout1_97) AT=860.025n

* CHECK dout1_98 Vdout1_98ck171 = 0.9 time = 860
.meas tran vdout1_98ck171 FIND v(dout1_98) AT=860.025n

* CHECK dout1_99 Vdout1_99ck171 = 0 time = 860
.meas tran vdout1_99ck171 FIND v(dout1_99) AT=860.025n

* CHECK dout1_100 Vdout1_100ck171 = 0 time = 860
.meas tran vdout1_100ck171 FIND v(dout1_100) AT=860.025n

* CHECK dout1_101 Vdout1_101ck171 = 0.9 time = 860
.meas tran vdout1_101ck171 FIND v(dout1_101) AT=860.025n

* CHECK dout1_102 Vdout1_102ck171 = 0.9 time = 860
.meas tran vdout1_102ck171 FIND v(dout1_102) AT=860.025n

* CHECK dout1_103 Vdout1_103ck171 = 0.9 time = 860
.meas tran vdout1_103ck171 FIND v(dout1_103) AT=860.025n

* CHECK dout1_104 Vdout1_104ck171 = 0.9 time = 860
.meas tran vdout1_104ck171 FIND v(dout1_104) AT=860.025n

* CHECK dout1_105 Vdout1_105ck171 = 0 time = 860
.meas tran vdout1_105ck171 FIND v(dout1_105) AT=860.025n

* CHECK dout1_106 Vdout1_106ck171 = 0 time = 860
.meas tran vdout1_106ck171 FIND v(dout1_106) AT=860.025n

* CHECK dout1_107 Vdout1_107ck171 = 0.9 time = 860
.meas tran vdout1_107ck171 FIND v(dout1_107) AT=860.025n

* CHECK dout1_108 Vdout1_108ck171 = 0 time = 860
.meas tran vdout1_108ck171 FIND v(dout1_108) AT=860.025n

* CHECK dout1_109 Vdout1_109ck171 = 0.9 time = 860
.meas tran vdout1_109ck171 FIND v(dout1_109) AT=860.025n

* CHECK dout1_110 Vdout1_110ck171 = 0.9 time = 860
.meas tran vdout1_110ck171 FIND v(dout1_110) AT=860.025n

* CHECK dout1_111 Vdout1_111ck171 = 0 time = 860
.meas tran vdout1_111ck171 FIND v(dout1_111) AT=860.025n

* CHECK dout1_112 Vdout1_112ck171 = 0.9 time = 860
.meas tran vdout1_112ck171 FIND v(dout1_112) AT=860.025n

* CHECK dout1_113 Vdout1_113ck171 = 0 time = 860
.meas tran vdout1_113ck171 FIND v(dout1_113) AT=860.025n

* CHECK dout1_114 Vdout1_114ck171 = 0.9 time = 860
.meas tran vdout1_114ck171 FIND v(dout1_114) AT=860.025n

* CHECK dout1_115 Vdout1_115ck171 = 0.9 time = 860
.meas tran vdout1_115ck171 FIND v(dout1_115) AT=860.025n

* CHECK dout1_116 Vdout1_116ck171 = 0 time = 860
.meas tran vdout1_116ck171 FIND v(dout1_116) AT=860.025n

* CHECK dout1_117 Vdout1_117ck171 = 0 time = 860
.meas tran vdout1_117ck171 FIND v(dout1_117) AT=860.025n

* CHECK dout1_118 Vdout1_118ck171 = 0.9 time = 860
.meas tran vdout1_118ck171 FIND v(dout1_118) AT=860.025n

* CHECK dout1_119 Vdout1_119ck171 = 0.9 time = 860
.meas tran vdout1_119ck171 FIND v(dout1_119) AT=860.025n

* CHECK dout1_0 Vdout1_0ck173 = 0 time = 870
.meas tran vdout1_0ck173 FIND v(dout1_0) AT=870.025n

* CHECK dout1_1 Vdout1_1ck173 = 0.9 time = 870
.meas tran vdout1_1ck173 FIND v(dout1_1) AT=870.025n

* CHECK dout1_2 Vdout1_2ck173 = 0.9 time = 870
.meas tran vdout1_2ck173 FIND v(dout1_2) AT=870.025n

* CHECK dout1_3 Vdout1_3ck173 = 0.9 time = 870
.meas tran vdout1_3ck173 FIND v(dout1_3) AT=870.025n

* CHECK dout1_4 Vdout1_4ck173 = 0 time = 870
.meas tran vdout1_4ck173 FIND v(dout1_4) AT=870.025n

* CHECK dout1_5 Vdout1_5ck173 = 0 time = 870
.meas tran vdout1_5ck173 FIND v(dout1_5) AT=870.025n

* CHECK dout1_6 Vdout1_6ck173 = 0 time = 870
.meas tran vdout1_6ck173 FIND v(dout1_6) AT=870.025n

* CHECK dout1_7 Vdout1_7ck173 = 0.9 time = 870
.meas tran vdout1_7ck173 FIND v(dout1_7) AT=870.025n

* CHECK dout1_8 Vdout1_8ck173 = 0 time = 870
.meas tran vdout1_8ck173 FIND v(dout1_8) AT=870.025n

* CHECK dout1_9 Vdout1_9ck173 = 0.9 time = 870
.meas tran vdout1_9ck173 FIND v(dout1_9) AT=870.025n

* CHECK dout1_10 Vdout1_10ck173 = 0 time = 870
.meas tran vdout1_10ck173 FIND v(dout1_10) AT=870.025n

* CHECK dout1_11 Vdout1_11ck173 = 0 time = 870
.meas tran vdout1_11ck173 FIND v(dout1_11) AT=870.025n

* CHECK dout1_12 Vdout1_12ck173 = 0 time = 870
.meas tran vdout1_12ck173 FIND v(dout1_12) AT=870.025n

* CHECK dout1_13 Vdout1_13ck173 = 0.9 time = 870
.meas tran vdout1_13ck173 FIND v(dout1_13) AT=870.025n

* CHECK dout1_14 Vdout1_14ck173 = 0 time = 870
.meas tran vdout1_14ck173 FIND v(dout1_14) AT=870.025n

* CHECK dout1_15 Vdout1_15ck173 = 0.9 time = 870
.meas tran vdout1_15ck173 FIND v(dout1_15) AT=870.025n

* CHECK dout1_16 Vdout1_16ck173 = 0.9 time = 870
.meas tran vdout1_16ck173 FIND v(dout1_16) AT=870.025n

* CHECK dout1_17 Vdout1_17ck173 = 0.9 time = 870
.meas tran vdout1_17ck173 FIND v(dout1_17) AT=870.025n

* CHECK dout1_18 Vdout1_18ck173 = 0 time = 870
.meas tran vdout1_18ck173 FIND v(dout1_18) AT=870.025n

* CHECK dout1_19 Vdout1_19ck173 = 0.9 time = 870
.meas tran vdout1_19ck173 FIND v(dout1_19) AT=870.025n

* CHECK dout1_20 Vdout1_20ck173 = 0.9 time = 870
.meas tran vdout1_20ck173 FIND v(dout1_20) AT=870.025n

* CHECK dout1_21 Vdout1_21ck173 = 0 time = 870
.meas tran vdout1_21ck173 FIND v(dout1_21) AT=870.025n

* CHECK dout1_22 Vdout1_22ck173 = 0.9 time = 870
.meas tran vdout1_22ck173 FIND v(dout1_22) AT=870.025n

* CHECK dout1_23 Vdout1_23ck173 = 0.9 time = 870
.meas tran vdout1_23ck173 FIND v(dout1_23) AT=870.025n

* CHECK dout1_24 Vdout1_24ck173 = 0.9 time = 870
.meas tran vdout1_24ck173 FIND v(dout1_24) AT=870.025n

* CHECK dout1_25 Vdout1_25ck173 = 0 time = 870
.meas tran vdout1_25ck173 FIND v(dout1_25) AT=870.025n

* CHECK dout1_26 Vdout1_26ck173 = 0 time = 870
.meas tran vdout1_26ck173 FIND v(dout1_26) AT=870.025n

* CHECK dout1_27 Vdout1_27ck173 = 0 time = 870
.meas tran vdout1_27ck173 FIND v(dout1_27) AT=870.025n

* CHECK dout1_28 Vdout1_28ck173 = 0.9 time = 870
.meas tran vdout1_28ck173 FIND v(dout1_28) AT=870.025n

* CHECK dout1_29 Vdout1_29ck173 = 0 time = 870
.meas tran vdout1_29ck173 FIND v(dout1_29) AT=870.025n

* CHECK dout1_30 Vdout1_30ck173 = 0.9 time = 870
.meas tran vdout1_30ck173 FIND v(dout1_30) AT=870.025n

* CHECK dout1_31 Vdout1_31ck173 = 0.9 time = 870
.meas tran vdout1_31ck173 FIND v(dout1_31) AT=870.025n

* CHECK dout1_32 Vdout1_32ck173 = 0 time = 870
.meas tran vdout1_32ck173 FIND v(dout1_32) AT=870.025n

* CHECK dout1_33 Vdout1_33ck173 = 0.9 time = 870
.meas tran vdout1_33ck173 FIND v(dout1_33) AT=870.025n

* CHECK dout1_34 Vdout1_34ck173 = 0 time = 870
.meas tran vdout1_34ck173 FIND v(dout1_34) AT=870.025n

* CHECK dout1_35 Vdout1_35ck173 = 0.9 time = 870
.meas tran vdout1_35ck173 FIND v(dout1_35) AT=870.025n

* CHECK dout1_36 Vdout1_36ck173 = 0 time = 870
.meas tran vdout1_36ck173 FIND v(dout1_36) AT=870.025n

* CHECK dout1_37 Vdout1_37ck173 = 0 time = 870
.meas tran vdout1_37ck173 FIND v(dout1_37) AT=870.025n

* CHECK dout1_38 Vdout1_38ck173 = 0 time = 870
.meas tran vdout1_38ck173 FIND v(dout1_38) AT=870.025n

* CHECK dout1_39 Vdout1_39ck173 = 0.9 time = 870
.meas tran vdout1_39ck173 FIND v(dout1_39) AT=870.025n

* CHECK dout1_40 Vdout1_40ck173 = 0 time = 870
.meas tran vdout1_40ck173 FIND v(dout1_40) AT=870.025n

* CHECK dout1_41 Vdout1_41ck173 = 0 time = 870
.meas tran vdout1_41ck173 FIND v(dout1_41) AT=870.025n

* CHECK dout1_42 Vdout1_42ck173 = 0 time = 870
.meas tran vdout1_42ck173 FIND v(dout1_42) AT=870.025n

* CHECK dout1_43 Vdout1_43ck173 = 0 time = 870
.meas tran vdout1_43ck173 FIND v(dout1_43) AT=870.025n

* CHECK dout1_44 Vdout1_44ck173 = 0 time = 870
.meas tran vdout1_44ck173 FIND v(dout1_44) AT=870.025n

* CHECK dout1_45 Vdout1_45ck173 = 0 time = 870
.meas tran vdout1_45ck173 FIND v(dout1_45) AT=870.025n

* CHECK dout1_46 Vdout1_46ck173 = 0 time = 870
.meas tran vdout1_46ck173 FIND v(dout1_46) AT=870.025n

* CHECK dout1_47 Vdout1_47ck173 = 0 time = 870
.meas tran vdout1_47ck173 FIND v(dout1_47) AT=870.025n

* CHECK dout1_48 Vdout1_48ck173 = 0.9 time = 870
.meas tran vdout1_48ck173 FIND v(dout1_48) AT=870.025n

* CHECK dout1_49 Vdout1_49ck173 = 0 time = 870
.meas tran vdout1_49ck173 FIND v(dout1_49) AT=870.025n

* CHECK dout1_50 Vdout1_50ck173 = 0 time = 870
.meas tran vdout1_50ck173 FIND v(dout1_50) AT=870.025n

* CHECK dout1_51 Vdout1_51ck173 = 0 time = 870
.meas tran vdout1_51ck173 FIND v(dout1_51) AT=870.025n

* CHECK dout1_52 Vdout1_52ck173 = 0.9 time = 870
.meas tran vdout1_52ck173 FIND v(dout1_52) AT=870.025n

* CHECK dout1_53 Vdout1_53ck173 = 0.9 time = 870
.meas tran vdout1_53ck173 FIND v(dout1_53) AT=870.025n

* CHECK dout1_54 Vdout1_54ck173 = 0 time = 870
.meas tran vdout1_54ck173 FIND v(dout1_54) AT=870.025n

* CHECK dout1_55 Vdout1_55ck173 = 0 time = 870
.meas tran vdout1_55ck173 FIND v(dout1_55) AT=870.025n

* CHECK dout1_56 Vdout1_56ck173 = 0 time = 870
.meas tran vdout1_56ck173 FIND v(dout1_56) AT=870.025n

* CHECK dout1_57 Vdout1_57ck173 = 0 time = 870
.meas tran vdout1_57ck173 FIND v(dout1_57) AT=870.025n

* CHECK dout1_58 Vdout1_58ck173 = 0 time = 870
.meas tran vdout1_58ck173 FIND v(dout1_58) AT=870.025n

* CHECK dout1_59 Vdout1_59ck173 = 0 time = 870
.meas tran vdout1_59ck173 FIND v(dout1_59) AT=870.025n

* CHECK dout1_60 Vdout1_60ck173 = 0 time = 870
.meas tran vdout1_60ck173 FIND v(dout1_60) AT=870.025n

* CHECK dout1_61 Vdout1_61ck173 = 0 time = 870
.meas tran vdout1_61ck173 FIND v(dout1_61) AT=870.025n

* CHECK dout1_62 Vdout1_62ck173 = 0 time = 870
.meas tran vdout1_62ck173 FIND v(dout1_62) AT=870.025n

* CHECK dout1_63 Vdout1_63ck173 = 0 time = 870
.meas tran vdout1_63ck173 FIND v(dout1_63) AT=870.025n

* CHECK dout1_64 Vdout1_64ck173 = 0 time = 870
.meas tran vdout1_64ck173 FIND v(dout1_64) AT=870.025n

* CHECK dout1_65 Vdout1_65ck173 = 0.9 time = 870
.meas tran vdout1_65ck173 FIND v(dout1_65) AT=870.025n

* CHECK dout1_66 Vdout1_66ck173 = 0.9 time = 870
.meas tran vdout1_66ck173 FIND v(dout1_66) AT=870.025n

* CHECK dout1_67 Vdout1_67ck173 = 0 time = 870
.meas tran vdout1_67ck173 FIND v(dout1_67) AT=870.025n

* CHECK dout1_68 Vdout1_68ck173 = 0 time = 870
.meas tran vdout1_68ck173 FIND v(dout1_68) AT=870.025n

* CHECK dout1_69 Vdout1_69ck173 = 0 time = 870
.meas tran vdout1_69ck173 FIND v(dout1_69) AT=870.025n

* CHECK dout1_70 Vdout1_70ck173 = 0 time = 870
.meas tran vdout1_70ck173 FIND v(dout1_70) AT=870.025n

* CHECK dout1_71 Vdout1_71ck173 = 0.9 time = 870
.meas tran vdout1_71ck173 FIND v(dout1_71) AT=870.025n

* CHECK dout1_72 Vdout1_72ck173 = 0 time = 870
.meas tran vdout1_72ck173 FIND v(dout1_72) AT=870.025n

* CHECK dout1_73 Vdout1_73ck173 = 0.9 time = 870
.meas tran vdout1_73ck173 FIND v(dout1_73) AT=870.025n

* CHECK dout1_74 Vdout1_74ck173 = 0.9 time = 870
.meas tran vdout1_74ck173 FIND v(dout1_74) AT=870.025n

* CHECK dout1_75 Vdout1_75ck173 = 0 time = 870
.meas tran vdout1_75ck173 FIND v(dout1_75) AT=870.025n

* CHECK dout1_76 Vdout1_76ck173 = 0 time = 870
.meas tran vdout1_76ck173 FIND v(dout1_76) AT=870.025n

* CHECK dout1_77 Vdout1_77ck173 = 0 time = 870
.meas tran vdout1_77ck173 FIND v(dout1_77) AT=870.025n

* CHECK dout1_78 Vdout1_78ck173 = 0.9 time = 870
.meas tran vdout1_78ck173 FIND v(dout1_78) AT=870.025n

* CHECK dout1_79 Vdout1_79ck173 = 0.9 time = 870
.meas tran vdout1_79ck173 FIND v(dout1_79) AT=870.025n

* CHECK dout1_80 Vdout1_80ck173 = 0.9 time = 870
.meas tran vdout1_80ck173 FIND v(dout1_80) AT=870.025n

* CHECK dout1_81 Vdout1_81ck173 = 0.9 time = 870
.meas tran vdout1_81ck173 FIND v(dout1_81) AT=870.025n

* CHECK dout1_82 Vdout1_82ck173 = 0 time = 870
.meas tran vdout1_82ck173 FIND v(dout1_82) AT=870.025n

* CHECK dout1_83 Vdout1_83ck173 = 0.9 time = 870
.meas tran vdout1_83ck173 FIND v(dout1_83) AT=870.025n

* CHECK dout1_84 Vdout1_84ck173 = 0.9 time = 870
.meas tran vdout1_84ck173 FIND v(dout1_84) AT=870.025n

* CHECK dout1_85 Vdout1_85ck173 = 0.9 time = 870
.meas tran vdout1_85ck173 FIND v(dout1_85) AT=870.025n

* CHECK dout1_86 Vdout1_86ck173 = 0 time = 870
.meas tran vdout1_86ck173 FIND v(dout1_86) AT=870.025n

* CHECK dout1_87 Vdout1_87ck173 = 0.9 time = 870
.meas tran vdout1_87ck173 FIND v(dout1_87) AT=870.025n

* CHECK dout1_88 Vdout1_88ck173 = 0.9 time = 870
.meas tran vdout1_88ck173 FIND v(dout1_88) AT=870.025n

* CHECK dout1_89 Vdout1_89ck173 = 0 time = 870
.meas tran vdout1_89ck173 FIND v(dout1_89) AT=870.025n

* CHECK dout1_90 Vdout1_90ck173 = 0.9 time = 870
.meas tran vdout1_90ck173 FIND v(dout1_90) AT=870.025n

* CHECK dout1_91 Vdout1_91ck173 = 0.9 time = 870
.meas tran vdout1_91ck173 FIND v(dout1_91) AT=870.025n

* CHECK dout1_92 Vdout1_92ck173 = 0.9 time = 870
.meas tran vdout1_92ck173 FIND v(dout1_92) AT=870.025n

* CHECK dout1_93 Vdout1_93ck173 = 0.9 time = 870
.meas tran vdout1_93ck173 FIND v(dout1_93) AT=870.025n

* CHECK dout1_94 Vdout1_94ck173 = 0 time = 870
.meas tran vdout1_94ck173 FIND v(dout1_94) AT=870.025n

* CHECK dout1_95 Vdout1_95ck173 = 0.9 time = 870
.meas tran vdout1_95ck173 FIND v(dout1_95) AT=870.025n

* CHECK dout1_96 Vdout1_96ck173 = 0 time = 870
.meas tran vdout1_96ck173 FIND v(dout1_96) AT=870.025n

* CHECK dout1_97 Vdout1_97ck173 = 0.9 time = 870
.meas tran vdout1_97ck173 FIND v(dout1_97) AT=870.025n

* CHECK dout1_98 Vdout1_98ck173 = 0 time = 870
.meas tran vdout1_98ck173 FIND v(dout1_98) AT=870.025n

* CHECK dout1_99 Vdout1_99ck173 = 0.9 time = 870
.meas tran vdout1_99ck173 FIND v(dout1_99) AT=870.025n

* CHECK dout1_100 Vdout1_100ck173 = 0.9 time = 870
.meas tran vdout1_100ck173 FIND v(dout1_100) AT=870.025n

* CHECK dout1_101 Vdout1_101ck173 = 0.9 time = 870
.meas tran vdout1_101ck173 FIND v(dout1_101) AT=870.025n

* CHECK dout1_102 Vdout1_102ck173 = 0 time = 870
.meas tran vdout1_102ck173 FIND v(dout1_102) AT=870.025n

* CHECK dout1_103 Vdout1_103ck173 = 0.9 time = 870
.meas tran vdout1_103ck173 FIND v(dout1_103) AT=870.025n

* CHECK dout1_104 Vdout1_104ck173 = 0 time = 870
.meas tran vdout1_104ck173 FIND v(dout1_104) AT=870.025n

* CHECK dout1_105 Vdout1_105ck173 = 0 time = 870
.meas tran vdout1_105ck173 FIND v(dout1_105) AT=870.025n

* CHECK dout1_106 Vdout1_106ck173 = 0.9 time = 870
.meas tran vdout1_106ck173 FIND v(dout1_106) AT=870.025n

* CHECK dout1_107 Vdout1_107ck173 = 0 time = 870
.meas tran vdout1_107ck173 FIND v(dout1_107) AT=870.025n

* CHECK dout1_108 Vdout1_108ck173 = 0.9 time = 870
.meas tran vdout1_108ck173 FIND v(dout1_108) AT=870.025n

* CHECK dout1_109 Vdout1_109ck173 = 0 time = 870
.meas tran vdout1_109ck173 FIND v(dout1_109) AT=870.025n

* CHECK dout1_110 Vdout1_110ck173 = 0.9 time = 870
.meas tran vdout1_110ck173 FIND v(dout1_110) AT=870.025n

* CHECK dout1_111 Vdout1_111ck173 = 0.9 time = 870
.meas tran vdout1_111ck173 FIND v(dout1_111) AT=870.025n

* CHECK dout1_112 Vdout1_112ck173 = 0.9 time = 870
.meas tran vdout1_112ck173 FIND v(dout1_112) AT=870.025n

* CHECK dout1_113 Vdout1_113ck173 = 0.9 time = 870
.meas tran vdout1_113ck173 FIND v(dout1_113) AT=870.025n

* CHECK dout1_114 Vdout1_114ck173 = 0.9 time = 870
.meas tran vdout1_114ck173 FIND v(dout1_114) AT=870.025n

* CHECK dout1_115 Vdout1_115ck173 = 0 time = 870
.meas tran vdout1_115ck173 FIND v(dout1_115) AT=870.025n

* CHECK dout1_116 Vdout1_116ck173 = 0 time = 870
.meas tran vdout1_116ck173 FIND v(dout1_116) AT=870.025n

* CHECK dout1_117 Vdout1_117ck173 = 0 time = 870
.meas tran vdout1_117ck173 FIND v(dout1_117) AT=870.025n

* CHECK dout1_118 Vdout1_118ck173 = 0.9 time = 870
.meas tran vdout1_118ck173 FIND v(dout1_118) AT=870.025n

* CHECK dout1_119 Vdout1_119ck173 = 0.9 time = 870
.meas tran vdout1_119ck173 FIND v(dout1_119) AT=870.025n

* CHECK dout1_0 Vdout1_0ck174 = 0 time = 875
.meas tran vdout1_0ck174 FIND v(dout1_0) AT=875.025n

* CHECK dout1_1 Vdout1_1ck174 = 0.9 time = 875
.meas tran vdout1_1ck174 FIND v(dout1_1) AT=875.025n

* CHECK dout1_2 Vdout1_2ck174 = 0 time = 875
.meas tran vdout1_2ck174 FIND v(dout1_2) AT=875.025n

* CHECK dout1_3 Vdout1_3ck174 = 0 time = 875
.meas tran vdout1_3ck174 FIND v(dout1_3) AT=875.025n

* CHECK dout1_4 Vdout1_4ck174 = 0 time = 875
.meas tran vdout1_4ck174 FIND v(dout1_4) AT=875.025n

* CHECK dout1_5 Vdout1_5ck174 = 0 time = 875
.meas tran vdout1_5ck174 FIND v(dout1_5) AT=875.025n

* CHECK dout1_6 Vdout1_6ck174 = 0 time = 875
.meas tran vdout1_6ck174 FIND v(dout1_6) AT=875.025n

* CHECK dout1_7 Vdout1_7ck174 = 0.9 time = 875
.meas tran vdout1_7ck174 FIND v(dout1_7) AT=875.025n

* CHECK dout1_8 Vdout1_8ck174 = 0 time = 875
.meas tran vdout1_8ck174 FIND v(dout1_8) AT=875.025n

* CHECK dout1_9 Vdout1_9ck174 = 0 time = 875
.meas tran vdout1_9ck174 FIND v(dout1_9) AT=875.025n

* CHECK dout1_10 Vdout1_10ck174 = 0.9 time = 875
.meas tran vdout1_10ck174 FIND v(dout1_10) AT=875.025n

* CHECK dout1_11 Vdout1_11ck174 = 0 time = 875
.meas tran vdout1_11ck174 FIND v(dout1_11) AT=875.025n

* CHECK dout1_12 Vdout1_12ck174 = 0 time = 875
.meas tran vdout1_12ck174 FIND v(dout1_12) AT=875.025n

* CHECK dout1_13 Vdout1_13ck174 = 0.9 time = 875
.meas tran vdout1_13ck174 FIND v(dout1_13) AT=875.025n

* CHECK dout1_14 Vdout1_14ck174 = 0 time = 875
.meas tran vdout1_14ck174 FIND v(dout1_14) AT=875.025n

* CHECK dout1_15 Vdout1_15ck174 = 0.9 time = 875
.meas tran vdout1_15ck174 FIND v(dout1_15) AT=875.025n

* CHECK dout1_16 Vdout1_16ck174 = 0 time = 875
.meas tran vdout1_16ck174 FIND v(dout1_16) AT=875.025n

* CHECK dout1_17 Vdout1_17ck174 = 0.9 time = 875
.meas tran vdout1_17ck174 FIND v(dout1_17) AT=875.025n

* CHECK dout1_18 Vdout1_18ck174 = 0.9 time = 875
.meas tran vdout1_18ck174 FIND v(dout1_18) AT=875.025n

* CHECK dout1_19 Vdout1_19ck174 = 0 time = 875
.meas tran vdout1_19ck174 FIND v(dout1_19) AT=875.025n

* CHECK dout1_20 Vdout1_20ck174 = 0 time = 875
.meas tran vdout1_20ck174 FIND v(dout1_20) AT=875.025n

* CHECK dout1_21 Vdout1_21ck174 = 0.9 time = 875
.meas tran vdout1_21ck174 FIND v(dout1_21) AT=875.025n

* CHECK dout1_22 Vdout1_22ck174 = 0 time = 875
.meas tran vdout1_22ck174 FIND v(dout1_22) AT=875.025n

* CHECK dout1_23 Vdout1_23ck174 = 0 time = 875
.meas tran vdout1_23ck174 FIND v(dout1_23) AT=875.025n

* CHECK dout1_24 Vdout1_24ck174 = 0.9 time = 875
.meas tran vdout1_24ck174 FIND v(dout1_24) AT=875.025n

* CHECK dout1_25 Vdout1_25ck174 = 0.9 time = 875
.meas tran vdout1_25ck174 FIND v(dout1_25) AT=875.025n

* CHECK dout1_26 Vdout1_26ck174 = 0.9 time = 875
.meas tran vdout1_26ck174 FIND v(dout1_26) AT=875.025n

* CHECK dout1_27 Vdout1_27ck174 = 0.9 time = 875
.meas tran vdout1_27ck174 FIND v(dout1_27) AT=875.025n

* CHECK dout1_28 Vdout1_28ck174 = 0.9 time = 875
.meas tran vdout1_28ck174 FIND v(dout1_28) AT=875.025n

* CHECK dout1_29 Vdout1_29ck174 = 0 time = 875
.meas tran vdout1_29ck174 FIND v(dout1_29) AT=875.025n

* CHECK dout1_30 Vdout1_30ck174 = 0.9 time = 875
.meas tran vdout1_30ck174 FIND v(dout1_30) AT=875.025n

* CHECK dout1_31 Vdout1_31ck174 = 0 time = 875
.meas tran vdout1_31ck174 FIND v(dout1_31) AT=875.025n

* CHECK dout1_32 Vdout1_32ck174 = 0.9 time = 875
.meas tran vdout1_32ck174 FIND v(dout1_32) AT=875.025n

* CHECK dout1_33 Vdout1_33ck174 = 0 time = 875
.meas tran vdout1_33ck174 FIND v(dout1_33) AT=875.025n

* CHECK dout1_34 Vdout1_34ck174 = 0 time = 875
.meas tran vdout1_34ck174 FIND v(dout1_34) AT=875.025n

* CHECK dout1_35 Vdout1_35ck174 = 0 time = 875
.meas tran vdout1_35ck174 FIND v(dout1_35) AT=875.025n

* CHECK dout1_36 Vdout1_36ck174 = 0 time = 875
.meas tran vdout1_36ck174 FIND v(dout1_36) AT=875.025n

* CHECK dout1_37 Vdout1_37ck174 = 0 time = 875
.meas tran vdout1_37ck174 FIND v(dout1_37) AT=875.025n

* CHECK dout1_38 Vdout1_38ck174 = 0 time = 875
.meas tran vdout1_38ck174 FIND v(dout1_38) AT=875.025n

* CHECK dout1_39 Vdout1_39ck174 = 0.9 time = 875
.meas tran vdout1_39ck174 FIND v(dout1_39) AT=875.025n

* CHECK dout1_40 Vdout1_40ck174 = 0.9 time = 875
.meas tran vdout1_40ck174 FIND v(dout1_40) AT=875.025n

* CHECK dout1_41 Vdout1_41ck174 = 0.9 time = 875
.meas tran vdout1_41ck174 FIND v(dout1_41) AT=875.025n

* CHECK dout1_42 Vdout1_42ck174 = 0 time = 875
.meas tran vdout1_42ck174 FIND v(dout1_42) AT=875.025n

* CHECK dout1_43 Vdout1_43ck174 = 0.9 time = 875
.meas tran vdout1_43ck174 FIND v(dout1_43) AT=875.025n

* CHECK dout1_44 Vdout1_44ck174 = 0 time = 875
.meas tran vdout1_44ck174 FIND v(dout1_44) AT=875.025n

* CHECK dout1_45 Vdout1_45ck174 = 0 time = 875
.meas tran vdout1_45ck174 FIND v(dout1_45) AT=875.025n

* CHECK dout1_46 Vdout1_46ck174 = 0 time = 875
.meas tran vdout1_46ck174 FIND v(dout1_46) AT=875.025n

* CHECK dout1_47 Vdout1_47ck174 = 0 time = 875
.meas tran vdout1_47ck174 FIND v(dout1_47) AT=875.025n

* CHECK dout1_48 Vdout1_48ck174 = 0 time = 875
.meas tran vdout1_48ck174 FIND v(dout1_48) AT=875.025n

* CHECK dout1_49 Vdout1_49ck174 = 0 time = 875
.meas tran vdout1_49ck174 FIND v(dout1_49) AT=875.025n

* CHECK dout1_50 Vdout1_50ck174 = 0 time = 875
.meas tran vdout1_50ck174 FIND v(dout1_50) AT=875.025n

* CHECK dout1_51 Vdout1_51ck174 = 0 time = 875
.meas tran vdout1_51ck174 FIND v(dout1_51) AT=875.025n

* CHECK dout1_52 Vdout1_52ck174 = 0.9 time = 875
.meas tran vdout1_52ck174 FIND v(dout1_52) AT=875.025n

* CHECK dout1_53 Vdout1_53ck174 = 0.9 time = 875
.meas tran vdout1_53ck174 FIND v(dout1_53) AT=875.025n

* CHECK dout1_54 Vdout1_54ck174 = 0 time = 875
.meas tran vdout1_54ck174 FIND v(dout1_54) AT=875.025n

* CHECK dout1_55 Vdout1_55ck174 = 0 time = 875
.meas tran vdout1_55ck174 FIND v(dout1_55) AT=875.025n

* CHECK dout1_56 Vdout1_56ck174 = 0.9 time = 875
.meas tran vdout1_56ck174 FIND v(dout1_56) AT=875.025n

* CHECK dout1_57 Vdout1_57ck174 = 0.9 time = 875
.meas tran vdout1_57ck174 FIND v(dout1_57) AT=875.025n

* CHECK dout1_58 Vdout1_58ck174 = 0.9 time = 875
.meas tran vdout1_58ck174 FIND v(dout1_58) AT=875.025n

* CHECK dout1_59 Vdout1_59ck174 = 0.9 time = 875
.meas tran vdout1_59ck174 FIND v(dout1_59) AT=875.025n

* CHECK dout1_60 Vdout1_60ck174 = 0.9 time = 875
.meas tran vdout1_60ck174 FIND v(dout1_60) AT=875.025n

* CHECK dout1_61 Vdout1_61ck174 = 0.9 time = 875
.meas tran vdout1_61ck174 FIND v(dout1_61) AT=875.025n

* CHECK dout1_62 Vdout1_62ck174 = 0 time = 875
.meas tran vdout1_62ck174 FIND v(dout1_62) AT=875.025n

* CHECK dout1_63 Vdout1_63ck174 = 0.9 time = 875
.meas tran vdout1_63ck174 FIND v(dout1_63) AT=875.025n

* CHECK dout1_64 Vdout1_64ck174 = 0.9 time = 875
.meas tran vdout1_64ck174 FIND v(dout1_64) AT=875.025n

* CHECK dout1_65 Vdout1_65ck174 = 0 time = 875
.meas tran vdout1_65ck174 FIND v(dout1_65) AT=875.025n

* CHECK dout1_66 Vdout1_66ck174 = 0.9 time = 875
.meas tran vdout1_66ck174 FIND v(dout1_66) AT=875.025n

* CHECK dout1_67 Vdout1_67ck174 = 0.9 time = 875
.meas tran vdout1_67ck174 FIND v(dout1_67) AT=875.025n

* CHECK dout1_68 Vdout1_68ck174 = 0 time = 875
.meas tran vdout1_68ck174 FIND v(dout1_68) AT=875.025n

* CHECK dout1_69 Vdout1_69ck174 = 0 time = 875
.meas tran vdout1_69ck174 FIND v(dout1_69) AT=875.025n

* CHECK dout1_70 Vdout1_70ck174 = 0.9 time = 875
.meas tran vdout1_70ck174 FIND v(dout1_70) AT=875.025n

* CHECK dout1_71 Vdout1_71ck174 = 0.9 time = 875
.meas tran vdout1_71ck174 FIND v(dout1_71) AT=875.025n

* CHECK dout1_72 Vdout1_72ck174 = 0.9 time = 875
.meas tran vdout1_72ck174 FIND v(dout1_72) AT=875.025n

* CHECK dout1_73 Vdout1_73ck174 = 0.9 time = 875
.meas tran vdout1_73ck174 FIND v(dout1_73) AT=875.025n

* CHECK dout1_74 Vdout1_74ck174 = 0 time = 875
.meas tran vdout1_74ck174 FIND v(dout1_74) AT=875.025n

* CHECK dout1_75 Vdout1_75ck174 = 0.9 time = 875
.meas tran vdout1_75ck174 FIND v(dout1_75) AT=875.025n

* CHECK dout1_76 Vdout1_76ck174 = 0.9 time = 875
.meas tran vdout1_76ck174 FIND v(dout1_76) AT=875.025n

* CHECK dout1_77 Vdout1_77ck174 = 0.9 time = 875
.meas tran vdout1_77ck174 FIND v(dout1_77) AT=875.025n

* CHECK dout1_78 Vdout1_78ck174 = 0 time = 875
.meas tran vdout1_78ck174 FIND v(dout1_78) AT=875.025n

* CHECK dout1_79 Vdout1_79ck174 = 0.9 time = 875
.meas tran vdout1_79ck174 FIND v(dout1_79) AT=875.025n

* CHECK dout1_80 Vdout1_80ck174 = 0 time = 875
.meas tran vdout1_80ck174 FIND v(dout1_80) AT=875.025n

* CHECK dout1_81 Vdout1_81ck174 = 0.9 time = 875
.meas tran vdout1_81ck174 FIND v(dout1_81) AT=875.025n

* CHECK dout1_82 Vdout1_82ck174 = 0 time = 875
.meas tran vdout1_82ck174 FIND v(dout1_82) AT=875.025n

* CHECK dout1_83 Vdout1_83ck174 = 0.9 time = 875
.meas tran vdout1_83ck174 FIND v(dout1_83) AT=875.025n

* CHECK dout1_84 Vdout1_84ck174 = 0 time = 875
.meas tran vdout1_84ck174 FIND v(dout1_84) AT=875.025n

* CHECK dout1_85 Vdout1_85ck174 = 0 time = 875
.meas tran vdout1_85ck174 FIND v(dout1_85) AT=875.025n

* CHECK dout1_86 Vdout1_86ck174 = 0 time = 875
.meas tran vdout1_86ck174 FIND v(dout1_86) AT=875.025n

* CHECK dout1_87 Vdout1_87ck174 = 0.9 time = 875
.meas tran vdout1_87ck174 FIND v(dout1_87) AT=875.025n

* CHECK dout1_88 Vdout1_88ck174 = 0 time = 875
.meas tran vdout1_88ck174 FIND v(dout1_88) AT=875.025n

* CHECK dout1_89 Vdout1_89ck174 = 0 time = 875
.meas tran vdout1_89ck174 FIND v(dout1_89) AT=875.025n

* CHECK dout1_90 Vdout1_90ck174 = 0.9 time = 875
.meas tran vdout1_90ck174 FIND v(dout1_90) AT=875.025n

* CHECK dout1_91 Vdout1_91ck174 = 0 time = 875
.meas tran vdout1_91ck174 FIND v(dout1_91) AT=875.025n

* CHECK dout1_92 Vdout1_92ck174 = 0 time = 875
.meas tran vdout1_92ck174 FIND v(dout1_92) AT=875.025n

* CHECK dout1_93 Vdout1_93ck174 = 0.9 time = 875
.meas tran vdout1_93ck174 FIND v(dout1_93) AT=875.025n

* CHECK dout1_94 Vdout1_94ck174 = 0 time = 875
.meas tran vdout1_94ck174 FIND v(dout1_94) AT=875.025n

* CHECK dout1_95 Vdout1_95ck174 = 0 time = 875
.meas tran vdout1_95ck174 FIND v(dout1_95) AT=875.025n

* CHECK dout1_96 Vdout1_96ck174 = 0.9 time = 875
.meas tran vdout1_96ck174 FIND v(dout1_96) AT=875.025n

* CHECK dout1_97 Vdout1_97ck174 = 0.9 time = 875
.meas tran vdout1_97ck174 FIND v(dout1_97) AT=875.025n

* CHECK dout1_98 Vdout1_98ck174 = 0.9 time = 875
.meas tran vdout1_98ck174 FIND v(dout1_98) AT=875.025n

* CHECK dout1_99 Vdout1_99ck174 = 0.9 time = 875
.meas tran vdout1_99ck174 FIND v(dout1_99) AT=875.025n

* CHECK dout1_100 Vdout1_100ck174 = 0 time = 875
.meas tran vdout1_100ck174 FIND v(dout1_100) AT=875.025n

* CHECK dout1_101 Vdout1_101ck174 = 0 time = 875
.meas tran vdout1_101ck174 FIND v(dout1_101) AT=875.025n

* CHECK dout1_102 Vdout1_102ck174 = 0 time = 875
.meas tran vdout1_102ck174 FIND v(dout1_102) AT=875.025n

* CHECK dout1_103 Vdout1_103ck174 = 0.9 time = 875
.meas tran vdout1_103ck174 FIND v(dout1_103) AT=875.025n

* CHECK dout1_104 Vdout1_104ck174 = 0.9 time = 875
.meas tran vdout1_104ck174 FIND v(dout1_104) AT=875.025n

* CHECK dout1_105 Vdout1_105ck174 = 0 time = 875
.meas tran vdout1_105ck174 FIND v(dout1_105) AT=875.025n

* CHECK dout1_106 Vdout1_106ck174 = 0.9 time = 875
.meas tran vdout1_106ck174 FIND v(dout1_106) AT=875.025n

* CHECK dout1_107 Vdout1_107ck174 = 0 time = 875
.meas tran vdout1_107ck174 FIND v(dout1_107) AT=875.025n

* CHECK dout1_108 Vdout1_108ck174 = 0.9 time = 875
.meas tran vdout1_108ck174 FIND v(dout1_108) AT=875.025n

* CHECK dout1_109 Vdout1_109ck174 = 0 time = 875
.meas tran vdout1_109ck174 FIND v(dout1_109) AT=875.025n

* CHECK dout1_110 Vdout1_110ck174 = 0 time = 875
.meas tran vdout1_110ck174 FIND v(dout1_110) AT=875.025n

* CHECK dout1_111 Vdout1_111ck174 = 0 time = 875
.meas tran vdout1_111ck174 FIND v(dout1_111) AT=875.025n

* CHECK dout1_112 Vdout1_112ck174 = 0.9 time = 875
.meas tran vdout1_112ck174 FIND v(dout1_112) AT=875.025n

* CHECK dout1_113 Vdout1_113ck174 = 0 time = 875
.meas tran vdout1_113ck174 FIND v(dout1_113) AT=875.025n

* CHECK dout1_114 Vdout1_114ck174 = 0 time = 875
.meas tran vdout1_114ck174 FIND v(dout1_114) AT=875.025n

* CHECK dout1_115 Vdout1_115ck174 = 0 time = 875
.meas tran vdout1_115ck174 FIND v(dout1_115) AT=875.025n

* CHECK dout1_116 Vdout1_116ck174 = 0 time = 875
.meas tran vdout1_116ck174 FIND v(dout1_116) AT=875.025n

* CHECK dout1_117 Vdout1_117ck174 = 0.9 time = 875
.meas tran vdout1_117ck174 FIND v(dout1_117) AT=875.025n

* CHECK dout1_118 Vdout1_118ck174 = 0.9 time = 875
.meas tran vdout1_118ck174 FIND v(dout1_118) AT=875.025n

* CHECK dout1_119 Vdout1_119ck174 = 0 time = 875
.meas tran vdout1_119ck174 FIND v(dout1_119) AT=875.025n

* CHECK dout1_0 Vdout1_0ck175 = 0 time = 880
.meas tran vdout1_0ck175 FIND v(dout1_0) AT=880.025n

* CHECK dout1_1 Vdout1_1ck175 = 0.9 time = 880
.meas tran vdout1_1ck175 FIND v(dout1_1) AT=880.025n

* CHECK dout1_2 Vdout1_2ck175 = 0.9 time = 880
.meas tran vdout1_2ck175 FIND v(dout1_2) AT=880.025n

* CHECK dout1_3 Vdout1_3ck175 = 0.9 time = 880
.meas tran vdout1_3ck175 FIND v(dout1_3) AT=880.025n

* CHECK dout1_4 Vdout1_4ck175 = 0 time = 880
.meas tran vdout1_4ck175 FIND v(dout1_4) AT=880.025n

* CHECK dout1_5 Vdout1_5ck175 = 0 time = 880
.meas tran vdout1_5ck175 FIND v(dout1_5) AT=880.025n

* CHECK dout1_6 Vdout1_6ck175 = 0 time = 880
.meas tran vdout1_6ck175 FIND v(dout1_6) AT=880.025n

* CHECK dout1_7 Vdout1_7ck175 = 0.9 time = 880
.meas tran vdout1_7ck175 FIND v(dout1_7) AT=880.025n

* CHECK dout1_8 Vdout1_8ck175 = 0 time = 880
.meas tran vdout1_8ck175 FIND v(dout1_8) AT=880.025n

* CHECK dout1_9 Vdout1_9ck175 = 0.9 time = 880
.meas tran vdout1_9ck175 FIND v(dout1_9) AT=880.025n

* CHECK dout1_10 Vdout1_10ck175 = 0 time = 880
.meas tran vdout1_10ck175 FIND v(dout1_10) AT=880.025n

* CHECK dout1_11 Vdout1_11ck175 = 0 time = 880
.meas tran vdout1_11ck175 FIND v(dout1_11) AT=880.025n

* CHECK dout1_12 Vdout1_12ck175 = 0 time = 880
.meas tran vdout1_12ck175 FIND v(dout1_12) AT=880.025n

* CHECK dout1_13 Vdout1_13ck175 = 0.9 time = 880
.meas tran vdout1_13ck175 FIND v(dout1_13) AT=880.025n

* CHECK dout1_14 Vdout1_14ck175 = 0 time = 880
.meas tran vdout1_14ck175 FIND v(dout1_14) AT=880.025n

* CHECK dout1_15 Vdout1_15ck175 = 0.9 time = 880
.meas tran vdout1_15ck175 FIND v(dout1_15) AT=880.025n

* CHECK dout1_16 Vdout1_16ck175 = 0.9 time = 880
.meas tran vdout1_16ck175 FIND v(dout1_16) AT=880.025n

* CHECK dout1_17 Vdout1_17ck175 = 0.9 time = 880
.meas tran vdout1_17ck175 FIND v(dout1_17) AT=880.025n

* CHECK dout1_18 Vdout1_18ck175 = 0 time = 880
.meas tran vdout1_18ck175 FIND v(dout1_18) AT=880.025n

* CHECK dout1_19 Vdout1_19ck175 = 0.9 time = 880
.meas tran vdout1_19ck175 FIND v(dout1_19) AT=880.025n

* CHECK dout1_20 Vdout1_20ck175 = 0.9 time = 880
.meas tran vdout1_20ck175 FIND v(dout1_20) AT=880.025n

* CHECK dout1_21 Vdout1_21ck175 = 0 time = 880
.meas tran vdout1_21ck175 FIND v(dout1_21) AT=880.025n

* CHECK dout1_22 Vdout1_22ck175 = 0.9 time = 880
.meas tran vdout1_22ck175 FIND v(dout1_22) AT=880.025n

* CHECK dout1_23 Vdout1_23ck175 = 0.9 time = 880
.meas tran vdout1_23ck175 FIND v(dout1_23) AT=880.025n

* CHECK dout1_24 Vdout1_24ck175 = 0.9 time = 880
.meas tran vdout1_24ck175 FIND v(dout1_24) AT=880.025n

* CHECK dout1_25 Vdout1_25ck175 = 0 time = 880
.meas tran vdout1_25ck175 FIND v(dout1_25) AT=880.025n

* CHECK dout1_26 Vdout1_26ck175 = 0 time = 880
.meas tran vdout1_26ck175 FIND v(dout1_26) AT=880.025n

* CHECK dout1_27 Vdout1_27ck175 = 0 time = 880
.meas tran vdout1_27ck175 FIND v(dout1_27) AT=880.025n

* CHECK dout1_28 Vdout1_28ck175 = 0.9 time = 880
.meas tran vdout1_28ck175 FIND v(dout1_28) AT=880.025n

* CHECK dout1_29 Vdout1_29ck175 = 0 time = 880
.meas tran vdout1_29ck175 FIND v(dout1_29) AT=880.025n

* CHECK dout1_30 Vdout1_30ck175 = 0.9 time = 880
.meas tran vdout1_30ck175 FIND v(dout1_30) AT=880.025n

* CHECK dout1_31 Vdout1_31ck175 = 0.9 time = 880
.meas tran vdout1_31ck175 FIND v(dout1_31) AT=880.025n

* CHECK dout1_32 Vdout1_32ck175 = 0 time = 880
.meas tran vdout1_32ck175 FIND v(dout1_32) AT=880.025n

* CHECK dout1_33 Vdout1_33ck175 = 0.9 time = 880
.meas tran vdout1_33ck175 FIND v(dout1_33) AT=880.025n

* CHECK dout1_34 Vdout1_34ck175 = 0 time = 880
.meas tran vdout1_34ck175 FIND v(dout1_34) AT=880.025n

* CHECK dout1_35 Vdout1_35ck175 = 0.9 time = 880
.meas tran vdout1_35ck175 FIND v(dout1_35) AT=880.025n

* CHECK dout1_36 Vdout1_36ck175 = 0 time = 880
.meas tran vdout1_36ck175 FIND v(dout1_36) AT=880.025n

* CHECK dout1_37 Vdout1_37ck175 = 0 time = 880
.meas tran vdout1_37ck175 FIND v(dout1_37) AT=880.025n

* CHECK dout1_38 Vdout1_38ck175 = 0 time = 880
.meas tran vdout1_38ck175 FIND v(dout1_38) AT=880.025n

* CHECK dout1_39 Vdout1_39ck175 = 0.9 time = 880
.meas tran vdout1_39ck175 FIND v(dout1_39) AT=880.025n

* CHECK dout1_40 Vdout1_40ck175 = 0 time = 880
.meas tran vdout1_40ck175 FIND v(dout1_40) AT=880.025n

* CHECK dout1_41 Vdout1_41ck175 = 0 time = 880
.meas tran vdout1_41ck175 FIND v(dout1_41) AT=880.025n

* CHECK dout1_42 Vdout1_42ck175 = 0 time = 880
.meas tran vdout1_42ck175 FIND v(dout1_42) AT=880.025n

* CHECK dout1_43 Vdout1_43ck175 = 0 time = 880
.meas tran vdout1_43ck175 FIND v(dout1_43) AT=880.025n

* CHECK dout1_44 Vdout1_44ck175 = 0 time = 880
.meas tran vdout1_44ck175 FIND v(dout1_44) AT=880.025n

* CHECK dout1_45 Vdout1_45ck175 = 0 time = 880
.meas tran vdout1_45ck175 FIND v(dout1_45) AT=880.025n

* CHECK dout1_46 Vdout1_46ck175 = 0 time = 880
.meas tran vdout1_46ck175 FIND v(dout1_46) AT=880.025n

* CHECK dout1_47 Vdout1_47ck175 = 0 time = 880
.meas tran vdout1_47ck175 FIND v(dout1_47) AT=880.025n

* CHECK dout1_48 Vdout1_48ck175 = 0.9 time = 880
.meas tran vdout1_48ck175 FIND v(dout1_48) AT=880.025n

* CHECK dout1_49 Vdout1_49ck175 = 0 time = 880
.meas tran vdout1_49ck175 FIND v(dout1_49) AT=880.025n

* CHECK dout1_50 Vdout1_50ck175 = 0 time = 880
.meas tran vdout1_50ck175 FIND v(dout1_50) AT=880.025n

* CHECK dout1_51 Vdout1_51ck175 = 0 time = 880
.meas tran vdout1_51ck175 FIND v(dout1_51) AT=880.025n

* CHECK dout1_52 Vdout1_52ck175 = 0.9 time = 880
.meas tran vdout1_52ck175 FIND v(dout1_52) AT=880.025n

* CHECK dout1_53 Vdout1_53ck175 = 0.9 time = 880
.meas tran vdout1_53ck175 FIND v(dout1_53) AT=880.025n

* CHECK dout1_54 Vdout1_54ck175 = 0 time = 880
.meas tran vdout1_54ck175 FIND v(dout1_54) AT=880.025n

* CHECK dout1_55 Vdout1_55ck175 = 0 time = 880
.meas tran vdout1_55ck175 FIND v(dout1_55) AT=880.025n

* CHECK dout1_56 Vdout1_56ck175 = 0 time = 880
.meas tran vdout1_56ck175 FIND v(dout1_56) AT=880.025n

* CHECK dout1_57 Vdout1_57ck175 = 0 time = 880
.meas tran vdout1_57ck175 FIND v(dout1_57) AT=880.025n

* CHECK dout1_58 Vdout1_58ck175 = 0 time = 880
.meas tran vdout1_58ck175 FIND v(dout1_58) AT=880.025n

* CHECK dout1_59 Vdout1_59ck175 = 0 time = 880
.meas tran vdout1_59ck175 FIND v(dout1_59) AT=880.025n

* CHECK dout1_60 Vdout1_60ck175 = 0 time = 880
.meas tran vdout1_60ck175 FIND v(dout1_60) AT=880.025n

* CHECK dout1_61 Vdout1_61ck175 = 0 time = 880
.meas tran vdout1_61ck175 FIND v(dout1_61) AT=880.025n

* CHECK dout1_62 Vdout1_62ck175 = 0 time = 880
.meas tran vdout1_62ck175 FIND v(dout1_62) AT=880.025n

* CHECK dout1_63 Vdout1_63ck175 = 0 time = 880
.meas tran vdout1_63ck175 FIND v(dout1_63) AT=880.025n

* CHECK dout1_64 Vdout1_64ck175 = 0 time = 880
.meas tran vdout1_64ck175 FIND v(dout1_64) AT=880.025n

* CHECK dout1_65 Vdout1_65ck175 = 0.9 time = 880
.meas tran vdout1_65ck175 FIND v(dout1_65) AT=880.025n

* CHECK dout1_66 Vdout1_66ck175 = 0.9 time = 880
.meas tran vdout1_66ck175 FIND v(dout1_66) AT=880.025n

* CHECK dout1_67 Vdout1_67ck175 = 0 time = 880
.meas tran vdout1_67ck175 FIND v(dout1_67) AT=880.025n

* CHECK dout1_68 Vdout1_68ck175 = 0 time = 880
.meas tran vdout1_68ck175 FIND v(dout1_68) AT=880.025n

* CHECK dout1_69 Vdout1_69ck175 = 0 time = 880
.meas tran vdout1_69ck175 FIND v(dout1_69) AT=880.025n

* CHECK dout1_70 Vdout1_70ck175 = 0 time = 880
.meas tran vdout1_70ck175 FIND v(dout1_70) AT=880.025n

* CHECK dout1_71 Vdout1_71ck175 = 0.9 time = 880
.meas tran vdout1_71ck175 FIND v(dout1_71) AT=880.025n

* CHECK dout1_72 Vdout1_72ck175 = 0 time = 880
.meas tran vdout1_72ck175 FIND v(dout1_72) AT=880.025n

* CHECK dout1_73 Vdout1_73ck175 = 0.9 time = 880
.meas tran vdout1_73ck175 FIND v(dout1_73) AT=880.025n

* CHECK dout1_74 Vdout1_74ck175 = 0.9 time = 880
.meas tran vdout1_74ck175 FIND v(dout1_74) AT=880.025n

* CHECK dout1_75 Vdout1_75ck175 = 0 time = 880
.meas tran vdout1_75ck175 FIND v(dout1_75) AT=880.025n

* CHECK dout1_76 Vdout1_76ck175 = 0 time = 880
.meas tran vdout1_76ck175 FIND v(dout1_76) AT=880.025n

* CHECK dout1_77 Vdout1_77ck175 = 0 time = 880
.meas tran vdout1_77ck175 FIND v(dout1_77) AT=880.025n

* CHECK dout1_78 Vdout1_78ck175 = 0.9 time = 880
.meas tran vdout1_78ck175 FIND v(dout1_78) AT=880.025n

* CHECK dout1_79 Vdout1_79ck175 = 0.9 time = 880
.meas tran vdout1_79ck175 FIND v(dout1_79) AT=880.025n

* CHECK dout1_80 Vdout1_80ck175 = 0.9 time = 880
.meas tran vdout1_80ck175 FIND v(dout1_80) AT=880.025n

* CHECK dout1_81 Vdout1_81ck175 = 0.9 time = 880
.meas tran vdout1_81ck175 FIND v(dout1_81) AT=880.025n

* CHECK dout1_82 Vdout1_82ck175 = 0 time = 880
.meas tran vdout1_82ck175 FIND v(dout1_82) AT=880.025n

* CHECK dout1_83 Vdout1_83ck175 = 0.9 time = 880
.meas tran vdout1_83ck175 FIND v(dout1_83) AT=880.025n

* CHECK dout1_84 Vdout1_84ck175 = 0.9 time = 880
.meas tran vdout1_84ck175 FIND v(dout1_84) AT=880.025n

* CHECK dout1_85 Vdout1_85ck175 = 0.9 time = 880
.meas tran vdout1_85ck175 FIND v(dout1_85) AT=880.025n

* CHECK dout1_86 Vdout1_86ck175 = 0 time = 880
.meas tran vdout1_86ck175 FIND v(dout1_86) AT=880.025n

* CHECK dout1_87 Vdout1_87ck175 = 0.9 time = 880
.meas tran vdout1_87ck175 FIND v(dout1_87) AT=880.025n

* CHECK dout1_88 Vdout1_88ck175 = 0.9 time = 880
.meas tran vdout1_88ck175 FIND v(dout1_88) AT=880.025n

* CHECK dout1_89 Vdout1_89ck175 = 0 time = 880
.meas tran vdout1_89ck175 FIND v(dout1_89) AT=880.025n

* CHECK dout1_90 Vdout1_90ck175 = 0.9 time = 880
.meas tran vdout1_90ck175 FIND v(dout1_90) AT=880.025n

* CHECK dout1_91 Vdout1_91ck175 = 0.9 time = 880
.meas tran vdout1_91ck175 FIND v(dout1_91) AT=880.025n

* CHECK dout1_92 Vdout1_92ck175 = 0.9 time = 880
.meas tran vdout1_92ck175 FIND v(dout1_92) AT=880.025n

* CHECK dout1_93 Vdout1_93ck175 = 0.9 time = 880
.meas tran vdout1_93ck175 FIND v(dout1_93) AT=880.025n

* CHECK dout1_94 Vdout1_94ck175 = 0 time = 880
.meas tran vdout1_94ck175 FIND v(dout1_94) AT=880.025n

* CHECK dout1_95 Vdout1_95ck175 = 0.9 time = 880
.meas tran vdout1_95ck175 FIND v(dout1_95) AT=880.025n

* CHECK dout1_96 Vdout1_96ck175 = 0 time = 880
.meas tran vdout1_96ck175 FIND v(dout1_96) AT=880.025n

* CHECK dout1_97 Vdout1_97ck175 = 0.9 time = 880
.meas tran vdout1_97ck175 FIND v(dout1_97) AT=880.025n

* CHECK dout1_98 Vdout1_98ck175 = 0 time = 880
.meas tran vdout1_98ck175 FIND v(dout1_98) AT=880.025n

* CHECK dout1_99 Vdout1_99ck175 = 0.9 time = 880
.meas tran vdout1_99ck175 FIND v(dout1_99) AT=880.025n

* CHECK dout1_100 Vdout1_100ck175 = 0.9 time = 880
.meas tran vdout1_100ck175 FIND v(dout1_100) AT=880.025n

* CHECK dout1_101 Vdout1_101ck175 = 0.9 time = 880
.meas tran vdout1_101ck175 FIND v(dout1_101) AT=880.025n

* CHECK dout1_102 Vdout1_102ck175 = 0 time = 880
.meas tran vdout1_102ck175 FIND v(dout1_102) AT=880.025n

* CHECK dout1_103 Vdout1_103ck175 = 0.9 time = 880
.meas tran vdout1_103ck175 FIND v(dout1_103) AT=880.025n

* CHECK dout1_104 Vdout1_104ck175 = 0 time = 880
.meas tran vdout1_104ck175 FIND v(dout1_104) AT=880.025n

* CHECK dout1_105 Vdout1_105ck175 = 0 time = 880
.meas tran vdout1_105ck175 FIND v(dout1_105) AT=880.025n

* CHECK dout1_106 Vdout1_106ck175 = 0.9 time = 880
.meas tran vdout1_106ck175 FIND v(dout1_106) AT=880.025n

* CHECK dout1_107 Vdout1_107ck175 = 0 time = 880
.meas tran vdout1_107ck175 FIND v(dout1_107) AT=880.025n

* CHECK dout1_108 Vdout1_108ck175 = 0.9 time = 880
.meas tran vdout1_108ck175 FIND v(dout1_108) AT=880.025n

* CHECK dout1_109 Vdout1_109ck175 = 0 time = 880
.meas tran vdout1_109ck175 FIND v(dout1_109) AT=880.025n

* CHECK dout1_110 Vdout1_110ck175 = 0.9 time = 880
.meas tran vdout1_110ck175 FIND v(dout1_110) AT=880.025n

* CHECK dout1_111 Vdout1_111ck175 = 0.9 time = 880
.meas tran vdout1_111ck175 FIND v(dout1_111) AT=880.025n

* CHECK dout1_112 Vdout1_112ck175 = 0.9 time = 880
.meas tran vdout1_112ck175 FIND v(dout1_112) AT=880.025n

* CHECK dout1_113 Vdout1_113ck175 = 0.9 time = 880
.meas tran vdout1_113ck175 FIND v(dout1_113) AT=880.025n

* CHECK dout1_114 Vdout1_114ck175 = 0.9 time = 880
.meas tran vdout1_114ck175 FIND v(dout1_114) AT=880.025n

* CHECK dout1_115 Vdout1_115ck175 = 0 time = 880
.meas tran vdout1_115ck175 FIND v(dout1_115) AT=880.025n

* CHECK dout1_116 Vdout1_116ck175 = 0 time = 880
.meas tran vdout1_116ck175 FIND v(dout1_116) AT=880.025n

* CHECK dout1_117 Vdout1_117ck175 = 0 time = 880
.meas tran vdout1_117ck175 FIND v(dout1_117) AT=880.025n

* CHECK dout1_118 Vdout1_118ck175 = 0.9 time = 880
.meas tran vdout1_118ck175 FIND v(dout1_118) AT=880.025n

* CHECK dout1_119 Vdout1_119ck175 = 0.9 time = 880
.meas tran vdout1_119ck175 FIND v(dout1_119) AT=880.025n

* CHECK dout1_0 Vdout1_0ck194 = 0 time = 975
.meas tran vdout1_0ck194 FIND v(dout1_0) AT=975.025n

* CHECK dout1_1 Vdout1_1ck194 = 0.9 time = 975
.meas tran vdout1_1ck194 FIND v(dout1_1) AT=975.025n

* CHECK dout1_2 Vdout1_2ck194 = 0.9 time = 975
.meas tran vdout1_2ck194 FIND v(dout1_2) AT=975.025n

* CHECK dout1_3 Vdout1_3ck194 = 0.9 time = 975
.meas tran vdout1_3ck194 FIND v(dout1_3) AT=975.025n

* CHECK dout1_4 Vdout1_4ck194 = 0 time = 975
.meas tran vdout1_4ck194 FIND v(dout1_4) AT=975.025n

* CHECK dout1_5 Vdout1_5ck194 = 0.9 time = 975
.meas tran vdout1_5ck194 FIND v(dout1_5) AT=975.025n

* CHECK dout1_6 Vdout1_6ck194 = 0.9 time = 975
.meas tran vdout1_6ck194 FIND v(dout1_6) AT=975.025n

* CHECK dout1_7 Vdout1_7ck194 = 0.9 time = 975
.meas tran vdout1_7ck194 FIND v(dout1_7) AT=975.025n

* CHECK dout1_8 Vdout1_8ck194 = 0.9 time = 975
.meas tran vdout1_8ck194 FIND v(dout1_8) AT=975.025n

* CHECK dout1_9 Vdout1_9ck194 = 0 time = 975
.meas tran vdout1_9ck194 FIND v(dout1_9) AT=975.025n

* CHECK dout1_10 Vdout1_10ck194 = 0.9 time = 975
.meas tran vdout1_10ck194 FIND v(dout1_10) AT=975.025n

* CHECK dout1_11 Vdout1_11ck194 = 0.9 time = 975
.meas tran vdout1_11ck194 FIND v(dout1_11) AT=975.025n

* CHECK dout1_12 Vdout1_12ck194 = 0 time = 975
.meas tran vdout1_12ck194 FIND v(dout1_12) AT=975.025n

* CHECK dout1_13 Vdout1_13ck194 = 0 time = 975
.meas tran vdout1_13ck194 FIND v(dout1_13) AT=975.025n

* CHECK dout1_14 Vdout1_14ck194 = 0.9 time = 975
.meas tran vdout1_14ck194 FIND v(dout1_14) AT=975.025n

* CHECK dout1_15 Vdout1_15ck194 = 0.9 time = 975
.meas tran vdout1_15ck194 FIND v(dout1_15) AT=975.025n

* CHECK dout1_16 Vdout1_16ck194 = 0 time = 975
.meas tran vdout1_16ck194 FIND v(dout1_16) AT=975.025n

* CHECK dout1_17 Vdout1_17ck194 = 0 time = 975
.meas tran vdout1_17ck194 FIND v(dout1_17) AT=975.025n

* CHECK dout1_18 Vdout1_18ck194 = 0.9 time = 975
.meas tran vdout1_18ck194 FIND v(dout1_18) AT=975.025n

* CHECK dout1_19 Vdout1_19ck194 = 0 time = 975
.meas tran vdout1_19ck194 FIND v(dout1_19) AT=975.025n

* CHECK dout1_20 Vdout1_20ck194 = 0.9 time = 975
.meas tran vdout1_20ck194 FIND v(dout1_20) AT=975.025n

* CHECK dout1_21 Vdout1_21ck194 = 0.9 time = 975
.meas tran vdout1_21ck194 FIND v(dout1_21) AT=975.025n

* CHECK dout1_22 Vdout1_22ck194 = 0.9 time = 975
.meas tran vdout1_22ck194 FIND v(dout1_22) AT=975.025n

* CHECK dout1_23 Vdout1_23ck194 = 0 time = 975
.meas tran vdout1_23ck194 FIND v(dout1_23) AT=975.025n

* CHECK dout1_24 Vdout1_24ck194 = 0.9 time = 975
.meas tran vdout1_24ck194 FIND v(dout1_24) AT=975.025n

* CHECK dout1_25 Vdout1_25ck194 = 0.9 time = 975
.meas tran vdout1_25ck194 FIND v(dout1_25) AT=975.025n

* CHECK dout1_26 Vdout1_26ck194 = 0.9 time = 975
.meas tran vdout1_26ck194 FIND v(dout1_26) AT=975.025n

* CHECK dout1_27 Vdout1_27ck194 = 0 time = 975
.meas tran vdout1_27ck194 FIND v(dout1_27) AT=975.025n

* CHECK dout1_28 Vdout1_28ck194 = 0 time = 975
.meas tran vdout1_28ck194 FIND v(dout1_28) AT=975.025n

* CHECK dout1_29 Vdout1_29ck194 = 0 time = 975
.meas tran vdout1_29ck194 FIND v(dout1_29) AT=975.025n

* CHECK dout1_30 Vdout1_30ck194 = 0 time = 975
.meas tran vdout1_30ck194 FIND v(dout1_30) AT=975.025n

* CHECK dout1_31 Vdout1_31ck194 = 0 time = 975
.meas tran vdout1_31ck194 FIND v(dout1_31) AT=975.025n

* CHECK dout1_32 Vdout1_32ck194 = 0.9 time = 975
.meas tran vdout1_32ck194 FIND v(dout1_32) AT=975.025n

* CHECK dout1_33 Vdout1_33ck194 = 0 time = 975
.meas tran vdout1_33ck194 FIND v(dout1_33) AT=975.025n

* CHECK dout1_34 Vdout1_34ck194 = 0 time = 975
.meas tran vdout1_34ck194 FIND v(dout1_34) AT=975.025n

* CHECK dout1_35 Vdout1_35ck194 = 0.9 time = 975
.meas tran vdout1_35ck194 FIND v(dout1_35) AT=975.025n

* CHECK dout1_36 Vdout1_36ck194 = 0.9 time = 975
.meas tran vdout1_36ck194 FIND v(dout1_36) AT=975.025n

* CHECK dout1_37 Vdout1_37ck194 = 0 time = 975
.meas tran vdout1_37ck194 FIND v(dout1_37) AT=975.025n

* CHECK dout1_38 Vdout1_38ck194 = 0 time = 975
.meas tran vdout1_38ck194 FIND v(dout1_38) AT=975.025n

* CHECK dout1_39 Vdout1_39ck194 = 0 time = 975
.meas tran vdout1_39ck194 FIND v(dout1_39) AT=975.025n

* CHECK dout1_40 Vdout1_40ck194 = 0 time = 975
.meas tran vdout1_40ck194 FIND v(dout1_40) AT=975.025n

* CHECK dout1_41 Vdout1_41ck194 = 0 time = 975
.meas tran vdout1_41ck194 FIND v(dout1_41) AT=975.025n

* CHECK dout1_42 Vdout1_42ck194 = 0 time = 975
.meas tran vdout1_42ck194 FIND v(dout1_42) AT=975.025n

* CHECK dout1_43 Vdout1_43ck194 = 0.9 time = 975
.meas tran vdout1_43ck194 FIND v(dout1_43) AT=975.025n

* CHECK dout1_44 Vdout1_44ck194 = 0.9 time = 975
.meas tran vdout1_44ck194 FIND v(dout1_44) AT=975.025n

* CHECK dout1_45 Vdout1_45ck194 = 0.9 time = 975
.meas tran vdout1_45ck194 FIND v(dout1_45) AT=975.025n

* CHECK dout1_46 Vdout1_46ck194 = 0 time = 975
.meas tran vdout1_46ck194 FIND v(dout1_46) AT=975.025n

* CHECK dout1_47 Vdout1_47ck194 = 0.9 time = 975
.meas tran vdout1_47ck194 FIND v(dout1_47) AT=975.025n

* CHECK dout1_48 Vdout1_48ck194 = 0 time = 975
.meas tran vdout1_48ck194 FIND v(dout1_48) AT=975.025n

* CHECK dout1_49 Vdout1_49ck194 = 0.9 time = 975
.meas tran vdout1_49ck194 FIND v(dout1_49) AT=975.025n

* CHECK dout1_50 Vdout1_50ck194 = 0 time = 975
.meas tran vdout1_50ck194 FIND v(dout1_50) AT=975.025n

* CHECK dout1_51 Vdout1_51ck194 = 0 time = 975
.meas tran vdout1_51ck194 FIND v(dout1_51) AT=975.025n

* CHECK dout1_52 Vdout1_52ck194 = 0 time = 975
.meas tran vdout1_52ck194 FIND v(dout1_52) AT=975.025n

* CHECK dout1_53 Vdout1_53ck194 = 0.9 time = 975
.meas tran vdout1_53ck194 FIND v(dout1_53) AT=975.025n

* CHECK dout1_54 Vdout1_54ck194 = 0.9 time = 975
.meas tran vdout1_54ck194 FIND v(dout1_54) AT=975.025n

* CHECK dout1_55 Vdout1_55ck194 = 0 time = 975
.meas tran vdout1_55ck194 FIND v(dout1_55) AT=975.025n

* CHECK dout1_56 Vdout1_56ck194 = 0 time = 975
.meas tran vdout1_56ck194 FIND v(dout1_56) AT=975.025n

* CHECK dout1_57 Vdout1_57ck194 = 0.9 time = 975
.meas tran vdout1_57ck194 FIND v(dout1_57) AT=975.025n

* CHECK dout1_58 Vdout1_58ck194 = 0.9 time = 975
.meas tran vdout1_58ck194 FIND v(dout1_58) AT=975.025n

* CHECK dout1_59 Vdout1_59ck194 = 0 time = 975
.meas tran vdout1_59ck194 FIND v(dout1_59) AT=975.025n

* CHECK dout1_60 Vdout1_60ck194 = 0.9 time = 975
.meas tran vdout1_60ck194 FIND v(dout1_60) AT=975.025n

* CHECK dout1_61 Vdout1_61ck194 = 0.9 time = 975
.meas tran vdout1_61ck194 FIND v(dout1_61) AT=975.025n

* CHECK dout1_62 Vdout1_62ck194 = 0 time = 975
.meas tran vdout1_62ck194 FIND v(dout1_62) AT=975.025n

* CHECK dout1_63 Vdout1_63ck194 = 0 time = 975
.meas tran vdout1_63ck194 FIND v(dout1_63) AT=975.025n

* CHECK dout1_64 Vdout1_64ck194 = 0 time = 975
.meas tran vdout1_64ck194 FIND v(dout1_64) AT=975.025n

* CHECK dout1_65 Vdout1_65ck194 = 0.9 time = 975
.meas tran vdout1_65ck194 FIND v(dout1_65) AT=975.025n

* CHECK dout1_66 Vdout1_66ck194 = 0.9 time = 975
.meas tran vdout1_66ck194 FIND v(dout1_66) AT=975.025n

* CHECK dout1_67 Vdout1_67ck194 = 0 time = 975
.meas tran vdout1_67ck194 FIND v(dout1_67) AT=975.025n

* CHECK dout1_68 Vdout1_68ck194 = 0.9 time = 975
.meas tran vdout1_68ck194 FIND v(dout1_68) AT=975.025n

* CHECK dout1_69 Vdout1_69ck194 = 0 time = 975
.meas tran vdout1_69ck194 FIND v(dout1_69) AT=975.025n

* CHECK dout1_70 Vdout1_70ck194 = 0 time = 975
.meas tran vdout1_70ck194 FIND v(dout1_70) AT=975.025n

* CHECK dout1_71 Vdout1_71ck194 = 0.9 time = 975
.meas tran vdout1_71ck194 FIND v(dout1_71) AT=975.025n

* CHECK dout1_72 Vdout1_72ck194 = 0.9 time = 975
.meas tran vdout1_72ck194 FIND v(dout1_72) AT=975.025n

* CHECK dout1_73 Vdout1_73ck194 = 0 time = 975
.meas tran vdout1_73ck194 FIND v(dout1_73) AT=975.025n

* CHECK dout1_74 Vdout1_74ck194 = 0 time = 975
.meas tran vdout1_74ck194 FIND v(dout1_74) AT=975.025n

* CHECK dout1_75 Vdout1_75ck194 = 0.9 time = 975
.meas tran vdout1_75ck194 FIND v(dout1_75) AT=975.025n

* CHECK dout1_76 Vdout1_76ck194 = 0 time = 975
.meas tran vdout1_76ck194 FIND v(dout1_76) AT=975.025n

* CHECK dout1_77 Vdout1_77ck194 = 0.9 time = 975
.meas tran vdout1_77ck194 FIND v(dout1_77) AT=975.025n

* CHECK dout1_78 Vdout1_78ck194 = 0 time = 975
.meas tran vdout1_78ck194 FIND v(dout1_78) AT=975.025n

* CHECK dout1_79 Vdout1_79ck194 = 0.9 time = 975
.meas tran vdout1_79ck194 FIND v(dout1_79) AT=975.025n

* CHECK dout1_80 Vdout1_80ck194 = 0 time = 975
.meas tran vdout1_80ck194 FIND v(dout1_80) AT=975.025n

* CHECK dout1_81 Vdout1_81ck194 = 0 time = 975
.meas tran vdout1_81ck194 FIND v(dout1_81) AT=975.025n

* CHECK dout1_82 Vdout1_82ck194 = 0.9 time = 975
.meas tran vdout1_82ck194 FIND v(dout1_82) AT=975.025n

* CHECK dout1_83 Vdout1_83ck194 = 0.9 time = 975
.meas tran vdout1_83ck194 FIND v(dout1_83) AT=975.025n

* CHECK dout1_84 Vdout1_84ck194 = 0 time = 975
.meas tran vdout1_84ck194 FIND v(dout1_84) AT=975.025n

* CHECK dout1_85 Vdout1_85ck194 = 0 time = 975
.meas tran vdout1_85ck194 FIND v(dout1_85) AT=975.025n

* CHECK dout1_86 Vdout1_86ck194 = 0 time = 975
.meas tran vdout1_86ck194 FIND v(dout1_86) AT=975.025n

* CHECK dout1_87 Vdout1_87ck194 = 0 time = 975
.meas tran vdout1_87ck194 FIND v(dout1_87) AT=975.025n

* CHECK dout1_88 Vdout1_88ck194 = 0 time = 975
.meas tran vdout1_88ck194 FIND v(dout1_88) AT=975.025n

* CHECK dout1_89 Vdout1_89ck194 = 0 time = 975
.meas tran vdout1_89ck194 FIND v(dout1_89) AT=975.025n

* CHECK dout1_90 Vdout1_90ck194 = 0 time = 975
.meas tran vdout1_90ck194 FIND v(dout1_90) AT=975.025n

* CHECK dout1_91 Vdout1_91ck194 = 0 time = 975
.meas tran vdout1_91ck194 FIND v(dout1_91) AT=975.025n

* CHECK dout1_92 Vdout1_92ck194 = 0 time = 975
.meas tran vdout1_92ck194 FIND v(dout1_92) AT=975.025n

* CHECK dout1_93 Vdout1_93ck194 = 0 time = 975
.meas tran vdout1_93ck194 FIND v(dout1_93) AT=975.025n

* CHECK dout1_94 Vdout1_94ck194 = 0 time = 975
.meas tran vdout1_94ck194 FIND v(dout1_94) AT=975.025n

* CHECK dout1_95 Vdout1_95ck194 = 0.9 time = 975
.meas tran vdout1_95ck194 FIND v(dout1_95) AT=975.025n

* CHECK dout1_96 Vdout1_96ck194 = 0.9 time = 975
.meas tran vdout1_96ck194 FIND v(dout1_96) AT=975.025n

* CHECK dout1_97 Vdout1_97ck194 = 0 time = 975
.meas tran vdout1_97ck194 FIND v(dout1_97) AT=975.025n

* CHECK dout1_98 Vdout1_98ck194 = 0 time = 975
.meas tran vdout1_98ck194 FIND v(dout1_98) AT=975.025n

* CHECK dout1_99 Vdout1_99ck194 = 0 time = 975
.meas tran vdout1_99ck194 FIND v(dout1_99) AT=975.025n

* CHECK dout1_100 Vdout1_100ck194 = 0 time = 975
.meas tran vdout1_100ck194 FIND v(dout1_100) AT=975.025n

* CHECK dout1_101 Vdout1_101ck194 = 0.9 time = 975
.meas tran vdout1_101ck194 FIND v(dout1_101) AT=975.025n

* CHECK dout1_102 Vdout1_102ck194 = 0 time = 975
.meas tran vdout1_102ck194 FIND v(dout1_102) AT=975.025n

* CHECK dout1_103 Vdout1_103ck194 = 0.9 time = 975
.meas tran vdout1_103ck194 FIND v(dout1_103) AT=975.025n

* CHECK dout1_104 Vdout1_104ck194 = 0.9 time = 975
.meas tran vdout1_104ck194 FIND v(dout1_104) AT=975.025n

* CHECK dout1_105 Vdout1_105ck194 = 0 time = 975
.meas tran vdout1_105ck194 FIND v(dout1_105) AT=975.025n

* CHECK dout1_106 Vdout1_106ck194 = 0.9 time = 975
.meas tran vdout1_106ck194 FIND v(dout1_106) AT=975.025n

* CHECK dout1_107 Vdout1_107ck194 = 0.9 time = 975
.meas tran vdout1_107ck194 FIND v(dout1_107) AT=975.025n

* CHECK dout1_108 Vdout1_108ck194 = 0 time = 975
.meas tran vdout1_108ck194 FIND v(dout1_108) AT=975.025n

* CHECK dout1_109 Vdout1_109ck194 = 0.9 time = 975
.meas tran vdout1_109ck194 FIND v(dout1_109) AT=975.025n

* CHECK dout1_110 Vdout1_110ck194 = 0 time = 975
.meas tran vdout1_110ck194 FIND v(dout1_110) AT=975.025n

* CHECK dout1_111 Vdout1_111ck194 = 0 time = 975
.meas tran vdout1_111ck194 FIND v(dout1_111) AT=975.025n

* CHECK dout1_112 Vdout1_112ck194 = 0 time = 975
.meas tran vdout1_112ck194 FIND v(dout1_112) AT=975.025n

* CHECK dout1_113 Vdout1_113ck194 = 0.9 time = 975
.meas tran vdout1_113ck194 FIND v(dout1_113) AT=975.025n

* CHECK dout1_114 Vdout1_114ck194 = 0.9 time = 975
.meas tran vdout1_114ck194 FIND v(dout1_114) AT=975.025n

* CHECK dout1_115 Vdout1_115ck194 = 0 time = 975
.meas tran vdout1_115ck194 FIND v(dout1_115) AT=975.025n

* CHECK dout1_116 Vdout1_116ck194 = 0.9 time = 975
.meas tran vdout1_116ck194 FIND v(dout1_116) AT=975.025n

* CHECK dout1_117 Vdout1_117ck194 = 0 time = 975
.meas tran vdout1_117ck194 FIND v(dout1_117) AT=975.025n

* CHECK dout1_118 Vdout1_118ck194 = 0 time = 975
.meas tran vdout1_118ck194 FIND v(dout1_118) AT=975.025n

* CHECK dout1_119 Vdout1_119ck194 = 0 time = 975
.meas tran vdout1_119ck194 FIND v(dout1_119) AT=975.025n

* CHECK dout1_0 Vdout1_0ck196 = 0 time = 985
.meas tran vdout1_0ck196 FIND v(dout1_0) AT=985.025n

* CHECK dout1_1 Vdout1_1ck196 = 0.9 time = 985
.meas tran vdout1_1ck196 FIND v(dout1_1) AT=985.025n

* CHECK dout1_2 Vdout1_2ck196 = 0.9 time = 985
.meas tran vdout1_2ck196 FIND v(dout1_2) AT=985.025n

* CHECK dout1_3 Vdout1_3ck196 = 0.9 time = 985
.meas tran vdout1_3ck196 FIND v(dout1_3) AT=985.025n

* CHECK dout1_4 Vdout1_4ck196 = 0 time = 985
.meas tran vdout1_4ck196 FIND v(dout1_4) AT=985.025n

* CHECK dout1_5 Vdout1_5ck196 = 0.9 time = 985
.meas tran vdout1_5ck196 FIND v(dout1_5) AT=985.025n

* CHECK dout1_6 Vdout1_6ck196 = 0.9 time = 985
.meas tran vdout1_6ck196 FIND v(dout1_6) AT=985.025n

* CHECK dout1_7 Vdout1_7ck196 = 0.9 time = 985
.meas tran vdout1_7ck196 FIND v(dout1_7) AT=985.025n

* CHECK dout1_8 Vdout1_8ck196 = 0.9 time = 985
.meas tran vdout1_8ck196 FIND v(dout1_8) AT=985.025n

* CHECK dout1_9 Vdout1_9ck196 = 0 time = 985
.meas tran vdout1_9ck196 FIND v(dout1_9) AT=985.025n

* CHECK dout1_10 Vdout1_10ck196 = 0.9 time = 985
.meas tran vdout1_10ck196 FIND v(dout1_10) AT=985.025n

* CHECK dout1_11 Vdout1_11ck196 = 0.9 time = 985
.meas tran vdout1_11ck196 FIND v(dout1_11) AT=985.025n

* CHECK dout1_12 Vdout1_12ck196 = 0 time = 985
.meas tran vdout1_12ck196 FIND v(dout1_12) AT=985.025n

* CHECK dout1_13 Vdout1_13ck196 = 0 time = 985
.meas tran vdout1_13ck196 FIND v(dout1_13) AT=985.025n

* CHECK dout1_14 Vdout1_14ck196 = 0.9 time = 985
.meas tran vdout1_14ck196 FIND v(dout1_14) AT=985.025n

* CHECK dout1_15 Vdout1_15ck196 = 0.9 time = 985
.meas tran vdout1_15ck196 FIND v(dout1_15) AT=985.025n

* CHECK dout1_16 Vdout1_16ck196 = 0 time = 985
.meas tran vdout1_16ck196 FIND v(dout1_16) AT=985.025n

* CHECK dout1_17 Vdout1_17ck196 = 0 time = 985
.meas tran vdout1_17ck196 FIND v(dout1_17) AT=985.025n

* CHECK dout1_18 Vdout1_18ck196 = 0.9 time = 985
.meas tran vdout1_18ck196 FIND v(dout1_18) AT=985.025n

* CHECK dout1_19 Vdout1_19ck196 = 0 time = 985
.meas tran vdout1_19ck196 FIND v(dout1_19) AT=985.025n

* CHECK dout1_20 Vdout1_20ck196 = 0.9 time = 985
.meas tran vdout1_20ck196 FIND v(dout1_20) AT=985.025n

* CHECK dout1_21 Vdout1_21ck196 = 0.9 time = 985
.meas tran vdout1_21ck196 FIND v(dout1_21) AT=985.025n

* CHECK dout1_22 Vdout1_22ck196 = 0.9 time = 985
.meas tran vdout1_22ck196 FIND v(dout1_22) AT=985.025n

* CHECK dout1_23 Vdout1_23ck196 = 0 time = 985
.meas tran vdout1_23ck196 FIND v(dout1_23) AT=985.025n

* CHECK dout1_24 Vdout1_24ck196 = 0.9 time = 985
.meas tran vdout1_24ck196 FIND v(dout1_24) AT=985.025n

* CHECK dout1_25 Vdout1_25ck196 = 0.9 time = 985
.meas tran vdout1_25ck196 FIND v(dout1_25) AT=985.025n

* CHECK dout1_26 Vdout1_26ck196 = 0.9 time = 985
.meas tran vdout1_26ck196 FIND v(dout1_26) AT=985.025n

* CHECK dout1_27 Vdout1_27ck196 = 0 time = 985
.meas tran vdout1_27ck196 FIND v(dout1_27) AT=985.025n

* CHECK dout1_28 Vdout1_28ck196 = 0 time = 985
.meas tran vdout1_28ck196 FIND v(dout1_28) AT=985.025n

* CHECK dout1_29 Vdout1_29ck196 = 0 time = 985
.meas tran vdout1_29ck196 FIND v(dout1_29) AT=985.025n

* CHECK dout1_30 Vdout1_30ck196 = 0 time = 985
.meas tran vdout1_30ck196 FIND v(dout1_30) AT=985.025n

* CHECK dout1_31 Vdout1_31ck196 = 0 time = 985
.meas tran vdout1_31ck196 FIND v(dout1_31) AT=985.025n

* CHECK dout1_32 Vdout1_32ck196 = 0.9 time = 985
.meas tran vdout1_32ck196 FIND v(dout1_32) AT=985.025n

* CHECK dout1_33 Vdout1_33ck196 = 0 time = 985
.meas tran vdout1_33ck196 FIND v(dout1_33) AT=985.025n

* CHECK dout1_34 Vdout1_34ck196 = 0 time = 985
.meas tran vdout1_34ck196 FIND v(dout1_34) AT=985.025n

* CHECK dout1_35 Vdout1_35ck196 = 0.9 time = 985
.meas tran vdout1_35ck196 FIND v(dout1_35) AT=985.025n

* CHECK dout1_36 Vdout1_36ck196 = 0.9 time = 985
.meas tran vdout1_36ck196 FIND v(dout1_36) AT=985.025n

* CHECK dout1_37 Vdout1_37ck196 = 0 time = 985
.meas tran vdout1_37ck196 FIND v(dout1_37) AT=985.025n

* CHECK dout1_38 Vdout1_38ck196 = 0 time = 985
.meas tran vdout1_38ck196 FIND v(dout1_38) AT=985.025n

* CHECK dout1_39 Vdout1_39ck196 = 0 time = 985
.meas tran vdout1_39ck196 FIND v(dout1_39) AT=985.025n

* CHECK dout1_40 Vdout1_40ck196 = 0 time = 985
.meas tran vdout1_40ck196 FIND v(dout1_40) AT=985.025n

* CHECK dout1_41 Vdout1_41ck196 = 0 time = 985
.meas tran vdout1_41ck196 FIND v(dout1_41) AT=985.025n

* CHECK dout1_42 Vdout1_42ck196 = 0 time = 985
.meas tran vdout1_42ck196 FIND v(dout1_42) AT=985.025n

* CHECK dout1_43 Vdout1_43ck196 = 0.9 time = 985
.meas tran vdout1_43ck196 FIND v(dout1_43) AT=985.025n

* CHECK dout1_44 Vdout1_44ck196 = 0.9 time = 985
.meas tran vdout1_44ck196 FIND v(dout1_44) AT=985.025n

* CHECK dout1_45 Vdout1_45ck196 = 0.9 time = 985
.meas tran vdout1_45ck196 FIND v(dout1_45) AT=985.025n

* CHECK dout1_46 Vdout1_46ck196 = 0 time = 985
.meas tran vdout1_46ck196 FIND v(dout1_46) AT=985.025n

* CHECK dout1_47 Vdout1_47ck196 = 0.9 time = 985
.meas tran vdout1_47ck196 FIND v(dout1_47) AT=985.025n

* CHECK dout1_48 Vdout1_48ck196 = 0 time = 985
.meas tran vdout1_48ck196 FIND v(dout1_48) AT=985.025n

* CHECK dout1_49 Vdout1_49ck196 = 0.9 time = 985
.meas tran vdout1_49ck196 FIND v(dout1_49) AT=985.025n

* CHECK dout1_50 Vdout1_50ck196 = 0 time = 985
.meas tran vdout1_50ck196 FIND v(dout1_50) AT=985.025n

* CHECK dout1_51 Vdout1_51ck196 = 0 time = 985
.meas tran vdout1_51ck196 FIND v(dout1_51) AT=985.025n

* CHECK dout1_52 Vdout1_52ck196 = 0 time = 985
.meas tran vdout1_52ck196 FIND v(dout1_52) AT=985.025n

* CHECK dout1_53 Vdout1_53ck196 = 0.9 time = 985
.meas tran vdout1_53ck196 FIND v(dout1_53) AT=985.025n

* CHECK dout1_54 Vdout1_54ck196 = 0.9 time = 985
.meas tran vdout1_54ck196 FIND v(dout1_54) AT=985.025n

* CHECK dout1_55 Vdout1_55ck196 = 0 time = 985
.meas tran vdout1_55ck196 FIND v(dout1_55) AT=985.025n

* CHECK dout1_56 Vdout1_56ck196 = 0 time = 985
.meas tran vdout1_56ck196 FIND v(dout1_56) AT=985.025n

* CHECK dout1_57 Vdout1_57ck196 = 0.9 time = 985
.meas tran vdout1_57ck196 FIND v(dout1_57) AT=985.025n

* CHECK dout1_58 Vdout1_58ck196 = 0.9 time = 985
.meas tran vdout1_58ck196 FIND v(dout1_58) AT=985.025n

* CHECK dout1_59 Vdout1_59ck196 = 0 time = 985
.meas tran vdout1_59ck196 FIND v(dout1_59) AT=985.025n

* CHECK dout1_60 Vdout1_60ck196 = 0.9 time = 985
.meas tran vdout1_60ck196 FIND v(dout1_60) AT=985.025n

* CHECK dout1_61 Vdout1_61ck196 = 0.9 time = 985
.meas tran vdout1_61ck196 FIND v(dout1_61) AT=985.025n

* CHECK dout1_62 Vdout1_62ck196 = 0 time = 985
.meas tran vdout1_62ck196 FIND v(dout1_62) AT=985.025n

* CHECK dout1_63 Vdout1_63ck196 = 0 time = 985
.meas tran vdout1_63ck196 FIND v(dout1_63) AT=985.025n

* CHECK dout1_64 Vdout1_64ck196 = 0 time = 985
.meas tran vdout1_64ck196 FIND v(dout1_64) AT=985.025n

* CHECK dout1_65 Vdout1_65ck196 = 0.9 time = 985
.meas tran vdout1_65ck196 FIND v(dout1_65) AT=985.025n

* CHECK dout1_66 Vdout1_66ck196 = 0.9 time = 985
.meas tran vdout1_66ck196 FIND v(dout1_66) AT=985.025n

* CHECK dout1_67 Vdout1_67ck196 = 0 time = 985
.meas tran vdout1_67ck196 FIND v(dout1_67) AT=985.025n

* CHECK dout1_68 Vdout1_68ck196 = 0.9 time = 985
.meas tran vdout1_68ck196 FIND v(dout1_68) AT=985.025n

* CHECK dout1_69 Vdout1_69ck196 = 0 time = 985
.meas tran vdout1_69ck196 FIND v(dout1_69) AT=985.025n

* CHECK dout1_70 Vdout1_70ck196 = 0 time = 985
.meas tran vdout1_70ck196 FIND v(dout1_70) AT=985.025n

* CHECK dout1_71 Vdout1_71ck196 = 0.9 time = 985
.meas tran vdout1_71ck196 FIND v(dout1_71) AT=985.025n

* CHECK dout1_72 Vdout1_72ck196 = 0.9 time = 985
.meas tran vdout1_72ck196 FIND v(dout1_72) AT=985.025n

* CHECK dout1_73 Vdout1_73ck196 = 0 time = 985
.meas tran vdout1_73ck196 FIND v(dout1_73) AT=985.025n

* CHECK dout1_74 Vdout1_74ck196 = 0 time = 985
.meas tran vdout1_74ck196 FIND v(dout1_74) AT=985.025n

* CHECK dout1_75 Vdout1_75ck196 = 0.9 time = 985
.meas tran vdout1_75ck196 FIND v(dout1_75) AT=985.025n

* CHECK dout1_76 Vdout1_76ck196 = 0 time = 985
.meas tran vdout1_76ck196 FIND v(dout1_76) AT=985.025n

* CHECK dout1_77 Vdout1_77ck196 = 0.9 time = 985
.meas tran vdout1_77ck196 FIND v(dout1_77) AT=985.025n

* CHECK dout1_78 Vdout1_78ck196 = 0 time = 985
.meas tran vdout1_78ck196 FIND v(dout1_78) AT=985.025n

* CHECK dout1_79 Vdout1_79ck196 = 0.9 time = 985
.meas tran vdout1_79ck196 FIND v(dout1_79) AT=985.025n

* CHECK dout1_80 Vdout1_80ck196 = 0 time = 985
.meas tran vdout1_80ck196 FIND v(dout1_80) AT=985.025n

* CHECK dout1_81 Vdout1_81ck196 = 0 time = 985
.meas tran vdout1_81ck196 FIND v(dout1_81) AT=985.025n

* CHECK dout1_82 Vdout1_82ck196 = 0.9 time = 985
.meas tran vdout1_82ck196 FIND v(dout1_82) AT=985.025n

* CHECK dout1_83 Vdout1_83ck196 = 0.9 time = 985
.meas tran vdout1_83ck196 FIND v(dout1_83) AT=985.025n

* CHECK dout1_84 Vdout1_84ck196 = 0 time = 985
.meas tran vdout1_84ck196 FIND v(dout1_84) AT=985.025n

* CHECK dout1_85 Vdout1_85ck196 = 0 time = 985
.meas tran vdout1_85ck196 FIND v(dout1_85) AT=985.025n

* CHECK dout1_86 Vdout1_86ck196 = 0 time = 985
.meas tran vdout1_86ck196 FIND v(dout1_86) AT=985.025n

* CHECK dout1_87 Vdout1_87ck196 = 0 time = 985
.meas tran vdout1_87ck196 FIND v(dout1_87) AT=985.025n

* CHECK dout1_88 Vdout1_88ck196 = 0 time = 985
.meas tran vdout1_88ck196 FIND v(dout1_88) AT=985.025n

* CHECK dout1_89 Vdout1_89ck196 = 0 time = 985
.meas tran vdout1_89ck196 FIND v(dout1_89) AT=985.025n

* CHECK dout1_90 Vdout1_90ck196 = 0 time = 985
.meas tran vdout1_90ck196 FIND v(dout1_90) AT=985.025n

* CHECK dout1_91 Vdout1_91ck196 = 0 time = 985
.meas tran vdout1_91ck196 FIND v(dout1_91) AT=985.025n

* CHECK dout1_92 Vdout1_92ck196 = 0 time = 985
.meas tran vdout1_92ck196 FIND v(dout1_92) AT=985.025n

* CHECK dout1_93 Vdout1_93ck196 = 0 time = 985
.meas tran vdout1_93ck196 FIND v(dout1_93) AT=985.025n

* CHECK dout1_94 Vdout1_94ck196 = 0 time = 985
.meas tran vdout1_94ck196 FIND v(dout1_94) AT=985.025n

* CHECK dout1_95 Vdout1_95ck196 = 0.9 time = 985
.meas tran vdout1_95ck196 FIND v(dout1_95) AT=985.025n

* CHECK dout1_96 Vdout1_96ck196 = 0.9 time = 985
.meas tran vdout1_96ck196 FIND v(dout1_96) AT=985.025n

* CHECK dout1_97 Vdout1_97ck196 = 0 time = 985
.meas tran vdout1_97ck196 FIND v(dout1_97) AT=985.025n

* CHECK dout1_98 Vdout1_98ck196 = 0 time = 985
.meas tran vdout1_98ck196 FIND v(dout1_98) AT=985.025n

* CHECK dout1_99 Vdout1_99ck196 = 0 time = 985
.meas tran vdout1_99ck196 FIND v(dout1_99) AT=985.025n

* CHECK dout1_100 Vdout1_100ck196 = 0 time = 985
.meas tran vdout1_100ck196 FIND v(dout1_100) AT=985.025n

* CHECK dout1_101 Vdout1_101ck196 = 0.9 time = 985
.meas tran vdout1_101ck196 FIND v(dout1_101) AT=985.025n

* CHECK dout1_102 Vdout1_102ck196 = 0 time = 985
.meas tran vdout1_102ck196 FIND v(dout1_102) AT=985.025n

* CHECK dout1_103 Vdout1_103ck196 = 0.9 time = 985
.meas tran vdout1_103ck196 FIND v(dout1_103) AT=985.025n

* CHECK dout1_104 Vdout1_104ck196 = 0.9 time = 985
.meas tran vdout1_104ck196 FIND v(dout1_104) AT=985.025n

* CHECK dout1_105 Vdout1_105ck196 = 0 time = 985
.meas tran vdout1_105ck196 FIND v(dout1_105) AT=985.025n

* CHECK dout1_106 Vdout1_106ck196 = 0.9 time = 985
.meas tran vdout1_106ck196 FIND v(dout1_106) AT=985.025n

* CHECK dout1_107 Vdout1_107ck196 = 0.9 time = 985
.meas tran vdout1_107ck196 FIND v(dout1_107) AT=985.025n

* CHECK dout1_108 Vdout1_108ck196 = 0 time = 985
.meas tran vdout1_108ck196 FIND v(dout1_108) AT=985.025n

* CHECK dout1_109 Vdout1_109ck196 = 0.9 time = 985
.meas tran vdout1_109ck196 FIND v(dout1_109) AT=985.025n

* CHECK dout1_110 Vdout1_110ck196 = 0 time = 985
.meas tran vdout1_110ck196 FIND v(dout1_110) AT=985.025n

* CHECK dout1_111 Vdout1_111ck196 = 0 time = 985
.meas tran vdout1_111ck196 FIND v(dout1_111) AT=985.025n

* CHECK dout1_112 Vdout1_112ck196 = 0 time = 985
.meas tran vdout1_112ck196 FIND v(dout1_112) AT=985.025n

* CHECK dout1_113 Vdout1_113ck196 = 0.9 time = 985
.meas tran vdout1_113ck196 FIND v(dout1_113) AT=985.025n

* CHECK dout1_114 Vdout1_114ck196 = 0.9 time = 985
.meas tran vdout1_114ck196 FIND v(dout1_114) AT=985.025n

* CHECK dout1_115 Vdout1_115ck196 = 0 time = 985
.meas tran vdout1_115ck196 FIND v(dout1_115) AT=985.025n

* CHECK dout1_116 Vdout1_116ck196 = 0.9 time = 985
.meas tran vdout1_116ck196 FIND v(dout1_116) AT=985.025n

* CHECK dout1_117 Vdout1_117ck196 = 0 time = 985
.meas tran vdout1_117ck196 FIND v(dout1_117) AT=985.025n

* CHECK dout1_118 Vdout1_118ck196 = 0 time = 985
.meas tran vdout1_118ck196 FIND v(dout1_118) AT=985.025n

* CHECK dout1_119 Vdout1_119ck196 = 0 time = 985
.meas tran vdout1_119ck196 FIND v(dout1_119) AT=985.025n

* CHECK dout1_0 Vdout1_0ck198 = 0.9 time = 995
.meas tran vdout1_0ck198 FIND v(dout1_0) AT=995.025n

* CHECK dout1_1 Vdout1_1ck198 = 0.9 time = 995
.meas tran vdout1_1ck198 FIND v(dout1_1) AT=995.025n

* CHECK dout1_2 Vdout1_2ck198 = 0 time = 995
.meas tran vdout1_2ck198 FIND v(dout1_2) AT=995.025n

* CHECK dout1_3 Vdout1_3ck198 = 0 time = 995
.meas tran vdout1_3ck198 FIND v(dout1_3) AT=995.025n

* CHECK dout1_4 Vdout1_4ck198 = 0 time = 995
.meas tran vdout1_4ck198 FIND v(dout1_4) AT=995.025n

* CHECK dout1_5 Vdout1_5ck198 = 0 time = 995
.meas tran vdout1_5ck198 FIND v(dout1_5) AT=995.025n

* CHECK dout1_6 Vdout1_6ck198 = 0.9 time = 995
.meas tran vdout1_6ck198 FIND v(dout1_6) AT=995.025n

* CHECK dout1_7 Vdout1_7ck198 = 0 time = 995
.meas tran vdout1_7ck198 FIND v(dout1_7) AT=995.025n

* CHECK dout1_8 Vdout1_8ck198 = 0 time = 995
.meas tran vdout1_8ck198 FIND v(dout1_8) AT=995.025n

* CHECK dout1_9 Vdout1_9ck198 = 0.9 time = 995
.meas tran vdout1_9ck198 FIND v(dout1_9) AT=995.025n

* CHECK dout1_10 Vdout1_10ck198 = 0 time = 995
.meas tran vdout1_10ck198 FIND v(dout1_10) AT=995.025n

* CHECK dout1_11 Vdout1_11ck198 = 0.9 time = 995
.meas tran vdout1_11ck198 FIND v(dout1_11) AT=995.025n

* CHECK dout1_12 Vdout1_12ck198 = 0 time = 995
.meas tran vdout1_12ck198 FIND v(dout1_12) AT=995.025n

* CHECK dout1_13 Vdout1_13ck198 = 0 time = 995
.meas tran vdout1_13ck198 FIND v(dout1_13) AT=995.025n

* CHECK dout1_14 Vdout1_14ck198 = 0.9 time = 995
.meas tran vdout1_14ck198 FIND v(dout1_14) AT=995.025n

* CHECK dout1_15 Vdout1_15ck198 = 0 time = 995
.meas tran vdout1_15ck198 FIND v(dout1_15) AT=995.025n

* CHECK dout1_16 Vdout1_16ck198 = 0.9 time = 995
.meas tran vdout1_16ck198 FIND v(dout1_16) AT=995.025n

* CHECK dout1_17 Vdout1_17ck198 = 0.9 time = 995
.meas tran vdout1_17ck198 FIND v(dout1_17) AT=995.025n

* CHECK dout1_18 Vdout1_18ck198 = 0 time = 995
.meas tran vdout1_18ck198 FIND v(dout1_18) AT=995.025n

* CHECK dout1_19 Vdout1_19ck198 = 0 time = 995
.meas tran vdout1_19ck198 FIND v(dout1_19) AT=995.025n

* CHECK dout1_20 Vdout1_20ck198 = 0 time = 995
.meas tran vdout1_20ck198 FIND v(dout1_20) AT=995.025n

* CHECK dout1_21 Vdout1_21ck198 = 0.9 time = 995
.meas tran vdout1_21ck198 FIND v(dout1_21) AT=995.025n

* CHECK dout1_22 Vdout1_22ck198 = 0.9 time = 995
.meas tran vdout1_22ck198 FIND v(dout1_22) AT=995.025n

* CHECK dout1_23 Vdout1_23ck198 = 0.9 time = 995
.meas tran vdout1_23ck198 FIND v(dout1_23) AT=995.025n

* CHECK dout1_24 Vdout1_24ck198 = 0.9 time = 995
.meas tran vdout1_24ck198 FIND v(dout1_24) AT=995.025n

* CHECK dout1_25 Vdout1_25ck198 = 0.9 time = 995
.meas tran vdout1_25ck198 FIND v(dout1_25) AT=995.025n

* CHECK dout1_26 Vdout1_26ck198 = 0.9 time = 995
.meas tran vdout1_26ck198 FIND v(dout1_26) AT=995.025n

* CHECK dout1_27 Vdout1_27ck198 = 0.9 time = 995
.meas tran vdout1_27ck198 FIND v(dout1_27) AT=995.025n

* CHECK dout1_28 Vdout1_28ck198 = 0 time = 995
.meas tran vdout1_28ck198 FIND v(dout1_28) AT=995.025n

* CHECK dout1_29 Vdout1_29ck198 = 0.9 time = 995
.meas tran vdout1_29ck198 FIND v(dout1_29) AT=995.025n

* CHECK dout1_30 Vdout1_30ck198 = 0 time = 995
.meas tran vdout1_30ck198 FIND v(dout1_30) AT=995.025n

* CHECK dout1_31 Vdout1_31ck198 = 0 time = 995
.meas tran vdout1_31ck198 FIND v(dout1_31) AT=995.025n

* CHECK dout1_32 Vdout1_32ck198 = 0.9 time = 995
.meas tran vdout1_32ck198 FIND v(dout1_32) AT=995.025n

* CHECK dout1_33 Vdout1_33ck198 = 0 time = 995
.meas tran vdout1_33ck198 FIND v(dout1_33) AT=995.025n

* CHECK dout1_34 Vdout1_34ck198 = 0.9 time = 995
.meas tran vdout1_34ck198 FIND v(dout1_34) AT=995.025n

* CHECK dout1_35 Vdout1_35ck198 = 0.9 time = 995
.meas tran vdout1_35ck198 FIND v(dout1_35) AT=995.025n

* CHECK dout1_36 Vdout1_36ck198 = 0.9 time = 995
.meas tran vdout1_36ck198 FIND v(dout1_36) AT=995.025n

* CHECK dout1_37 Vdout1_37ck198 = 0.9 time = 995
.meas tran vdout1_37ck198 FIND v(dout1_37) AT=995.025n

* CHECK dout1_38 Vdout1_38ck198 = 0 time = 995
.meas tran vdout1_38ck198 FIND v(dout1_38) AT=995.025n

* CHECK dout1_39 Vdout1_39ck198 = 0.9 time = 995
.meas tran vdout1_39ck198 FIND v(dout1_39) AT=995.025n

* CHECK dout1_40 Vdout1_40ck198 = 0 time = 995
.meas tran vdout1_40ck198 FIND v(dout1_40) AT=995.025n

* CHECK dout1_41 Vdout1_41ck198 = 0 time = 995
.meas tran vdout1_41ck198 FIND v(dout1_41) AT=995.025n

* CHECK dout1_42 Vdout1_42ck198 = 0.9 time = 995
.meas tran vdout1_42ck198 FIND v(dout1_42) AT=995.025n

* CHECK dout1_43 Vdout1_43ck198 = 0 time = 995
.meas tran vdout1_43ck198 FIND v(dout1_43) AT=995.025n

* CHECK dout1_44 Vdout1_44ck198 = 0 time = 995
.meas tran vdout1_44ck198 FIND v(dout1_44) AT=995.025n

* CHECK dout1_45 Vdout1_45ck198 = 0.9 time = 995
.meas tran vdout1_45ck198 FIND v(dout1_45) AT=995.025n

* CHECK dout1_46 Vdout1_46ck198 = 0 time = 995
.meas tran vdout1_46ck198 FIND v(dout1_46) AT=995.025n

* CHECK dout1_47 Vdout1_47ck198 = 0 time = 995
.meas tran vdout1_47ck198 FIND v(dout1_47) AT=995.025n

* CHECK dout1_48 Vdout1_48ck198 = 0 time = 995
.meas tran vdout1_48ck198 FIND v(dout1_48) AT=995.025n

* CHECK dout1_49 Vdout1_49ck198 = 0 time = 995
.meas tran vdout1_49ck198 FIND v(dout1_49) AT=995.025n

* CHECK dout1_50 Vdout1_50ck198 = 0.9 time = 995
.meas tran vdout1_50ck198 FIND v(dout1_50) AT=995.025n

* CHECK dout1_51 Vdout1_51ck198 = 0 time = 995
.meas tran vdout1_51ck198 FIND v(dout1_51) AT=995.025n

* CHECK dout1_52 Vdout1_52ck198 = 0 time = 995
.meas tran vdout1_52ck198 FIND v(dout1_52) AT=995.025n

* CHECK dout1_53 Vdout1_53ck198 = 0.9 time = 995
.meas tran vdout1_53ck198 FIND v(dout1_53) AT=995.025n

* CHECK dout1_54 Vdout1_54ck198 = 0 time = 995
.meas tran vdout1_54ck198 FIND v(dout1_54) AT=995.025n

* CHECK dout1_55 Vdout1_55ck198 = 0.9 time = 995
.meas tran vdout1_55ck198 FIND v(dout1_55) AT=995.025n

* CHECK dout1_56 Vdout1_56ck198 = 0.9 time = 995
.meas tran vdout1_56ck198 FIND v(dout1_56) AT=995.025n

* CHECK dout1_57 Vdout1_57ck198 = 0.9 time = 995
.meas tran vdout1_57ck198 FIND v(dout1_57) AT=995.025n

* CHECK dout1_58 Vdout1_58ck198 = 0 time = 995
.meas tran vdout1_58ck198 FIND v(dout1_58) AT=995.025n

* CHECK dout1_59 Vdout1_59ck198 = 0 time = 995
.meas tran vdout1_59ck198 FIND v(dout1_59) AT=995.025n

* CHECK dout1_60 Vdout1_60ck198 = 0.9 time = 995
.meas tran vdout1_60ck198 FIND v(dout1_60) AT=995.025n

* CHECK dout1_61 Vdout1_61ck198 = 0.9 time = 995
.meas tran vdout1_61ck198 FIND v(dout1_61) AT=995.025n

* CHECK dout1_62 Vdout1_62ck198 = 0 time = 995
.meas tran vdout1_62ck198 FIND v(dout1_62) AT=995.025n

* CHECK dout1_63 Vdout1_63ck198 = 0.9 time = 995
.meas tran vdout1_63ck198 FIND v(dout1_63) AT=995.025n

* CHECK dout1_64 Vdout1_64ck198 = 0 time = 995
.meas tran vdout1_64ck198 FIND v(dout1_64) AT=995.025n

* CHECK dout1_65 Vdout1_65ck198 = 0.9 time = 995
.meas tran vdout1_65ck198 FIND v(dout1_65) AT=995.025n

* CHECK dout1_66 Vdout1_66ck198 = 0.9 time = 995
.meas tran vdout1_66ck198 FIND v(dout1_66) AT=995.025n

* CHECK dout1_67 Vdout1_67ck198 = 0.9 time = 995
.meas tran vdout1_67ck198 FIND v(dout1_67) AT=995.025n

* CHECK dout1_68 Vdout1_68ck198 = 0.9 time = 995
.meas tran vdout1_68ck198 FIND v(dout1_68) AT=995.025n

* CHECK dout1_69 Vdout1_69ck198 = 0.9 time = 995
.meas tran vdout1_69ck198 FIND v(dout1_69) AT=995.025n

* CHECK dout1_70 Vdout1_70ck198 = 0.9 time = 995
.meas tran vdout1_70ck198 FIND v(dout1_70) AT=995.025n

* CHECK dout1_71 Vdout1_71ck198 = 0 time = 995
.meas tran vdout1_71ck198 FIND v(dout1_71) AT=995.025n

* CHECK dout1_72 Vdout1_72ck198 = 0 time = 995
.meas tran vdout1_72ck198 FIND v(dout1_72) AT=995.025n

* CHECK dout1_73 Vdout1_73ck198 = 0.9 time = 995
.meas tran vdout1_73ck198 FIND v(dout1_73) AT=995.025n

* CHECK dout1_74 Vdout1_74ck198 = 0.9 time = 995
.meas tran vdout1_74ck198 FIND v(dout1_74) AT=995.025n

* CHECK dout1_75 Vdout1_75ck198 = 0.9 time = 995
.meas tran vdout1_75ck198 FIND v(dout1_75) AT=995.025n

* CHECK dout1_76 Vdout1_76ck198 = 0 time = 995
.meas tran vdout1_76ck198 FIND v(dout1_76) AT=995.025n

* CHECK dout1_77 Vdout1_77ck198 = 0.9 time = 995
.meas tran vdout1_77ck198 FIND v(dout1_77) AT=995.025n

* CHECK dout1_78 Vdout1_78ck198 = 0 time = 995
.meas tran vdout1_78ck198 FIND v(dout1_78) AT=995.025n

* CHECK dout1_79 Vdout1_79ck198 = 0 time = 995
.meas tran vdout1_79ck198 FIND v(dout1_79) AT=995.025n

* CHECK dout1_80 Vdout1_80ck198 = 0 time = 995
.meas tran vdout1_80ck198 FIND v(dout1_80) AT=995.025n

* CHECK dout1_81 Vdout1_81ck198 = 0.9 time = 995
.meas tran vdout1_81ck198 FIND v(dout1_81) AT=995.025n

* CHECK dout1_82 Vdout1_82ck198 = 0.9 time = 995
.meas tran vdout1_82ck198 FIND v(dout1_82) AT=995.025n

* CHECK dout1_83 Vdout1_83ck198 = 0 time = 995
.meas tran vdout1_83ck198 FIND v(dout1_83) AT=995.025n

* CHECK dout1_84 Vdout1_84ck198 = 0.9 time = 995
.meas tran vdout1_84ck198 FIND v(dout1_84) AT=995.025n

* CHECK dout1_85 Vdout1_85ck198 = 0 time = 995
.meas tran vdout1_85ck198 FIND v(dout1_85) AT=995.025n

* CHECK dout1_86 Vdout1_86ck198 = 0.9 time = 995
.meas tran vdout1_86ck198 FIND v(dout1_86) AT=995.025n

* CHECK dout1_87 Vdout1_87ck198 = 0 time = 995
.meas tran vdout1_87ck198 FIND v(dout1_87) AT=995.025n

* CHECK dout1_88 Vdout1_88ck198 = 0.9 time = 995
.meas tran vdout1_88ck198 FIND v(dout1_88) AT=995.025n

* CHECK dout1_89 Vdout1_89ck198 = 0 time = 995
.meas tran vdout1_89ck198 FIND v(dout1_89) AT=995.025n

* CHECK dout1_90 Vdout1_90ck198 = 0.9 time = 995
.meas tran vdout1_90ck198 FIND v(dout1_90) AT=995.025n

* CHECK dout1_91 Vdout1_91ck198 = 0 time = 995
.meas tran vdout1_91ck198 FIND v(dout1_91) AT=995.025n

* CHECK dout1_92 Vdout1_92ck198 = 0 time = 995
.meas tran vdout1_92ck198 FIND v(dout1_92) AT=995.025n

* CHECK dout1_93 Vdout1_93ck198 = 0 time = 995
.meas tran vdout1_93ck198 FIND v(dout1_93) AT=995.025n

* CHECK dout1_94 Vdout1_94ck198 = 0 time = 995
.meas tran vdout1_94ck198 FIND v(dout1_94) AT=995.025n

* CHECK dout1_95 Vdout1_95ck198 = 0 time = 995
.meas tran vdout1_95ck198 FIND v(dout1_95) AT=995.025n

* CHECK dout1_96 Vdout1_96ck198 = 0 time = 995
.meas tran vdout1_96ck198 FIND v(dout1_96) AT=995.025n

* CHECK dout1_97 Vdout1_97ck198 = 0.9 time = 995
.meas tran vdout1_97ck198 FIND v(dout1_97) AT=995.025n

* CHECK dout1_98 Vdout1_98ck198 = 0.9 time = 995
.meas tran vdout1_98ck198 FIND v(dout1_98) AT=995.025n

* CHECK dout1_99 Vdout1_99ck198 = 0.9 time = 995
.meas tran vdout1_99ck198 FIND v(dout1_99) AT=995.025n

* CHECK dout1_100 Vdout1_100ck198 = 0 time = 995
.meas tran vdout1_100ck198 FIND v(dout1_100) AT=995.025n

* CHECK dout1_101 Vdout1_101ck198 = 0.9 time = 995
.meas tran vdout1_101ck198 FIND v(dout1_101) AT=995.025n

* CHECK dout1_102 Vdout1_102ck198 = 0.9 time = 995
.meas tran vdout1_102ck198 FIND v(dout1_102) AT=995.025n

* CHECK dout1_103 Vdout1_103ck198 = 0 time = 995
.meas tran vdout1_103ck198 FIND v(dout1_103) AT=995.025n

* CHECK dout1_104 Vdout1_104ck198 = 0 time = 995
.meas tran vdout1_104ck198 FIND v(dout1_104) AT=995.025n

* CHECK dout1_105 Vdout1_105ck198 = 0.9 time = 995
.meas tran vdout1_105ck198 FIND v(dout1_105) AT=995.025n

* CHECK dout1_106 Vdout1_106ck198 = 0 time = 995
.meas tran vdout1_106ck198 FIND v(dout1_106) AT=995.025n

* CHECK dout1_107 Vdout1_107ck198 = 0 time = 995
.meas tran vdout1_107ck198 FIND v(dout1_107) AT=995.025n

* CHECK dout1_108 Vdout1_108ck198 = 0 time = 995
.meas tran vdout1_108ck198 FIND v(dout1_108) AT=995.025n

* CHECK dout1_109 Vdout1_109ck198 = 0 time = 995
.meas tran vdout1_109ck198 FIND v(dout1_109) AT=995.025n

* CHECK dout1_110 Vdout1_110ck198 = 0.9 time = 995
.meas tran vdout1_110ck198 FIND v(dout1_110) AT=995.025n

* CHECK dout1_111 Vdout1_111ck198 = 0 time = 995
.meas tran vdout1_111ck198 FIND v(dout1_111) AT=995.025n

* CHECK dout1_112 Vdout1_112ck198 = 0.9 time = 995
.meas tran vdout1_112ck198 FIND v(dout1_112) AT=995.025n

* CHECK dout1_113 Vdout1_113ck198 = 0 time = 995
.meas tran vdout1_113ck198 FIND v(dout1_113) AT=995.025n

* CHECK dout1_114 Vdout1_114ck198 = 0.9 time = 995
.meas tran vdout1_114ck198 FIND v(dout1_114) AT=995.025n

* CHECK dout1_115 Vdout1_115ck198 = 0.9 time = 995
.meas tran vdout1_115ck198 FIND v(dout1_115) AT=995.025n

* CHECK dout1_116 Vdout1_116ck198 = 0.9 time = 995
.meas tran vdout1_116ck198 FIND v(dout1_116) AT=995.025n

* CHECK dout1_117 Vdout1_117ck198 = 0.9 time = 995
.meas tran vdout1_117ck198 FIND v(dout1_117) AT=995.025n

* CHECK dout1_118 Vdout1_118ck198 = 0.9 time = 995
.meas tran vdout1_118ck198 FIND v(dout1_118) AT=995.025n

* CHECK dout1_119 Vdout1_119ck198 = 0 time = 995
.meas tran vdout1_119ck198 FIND v(dout1_119) AT=995.025n

* CHECK dout1_0 Vdout1_0ck199 = 0.9 time = 1000
.meas tran vdout1_0ck199 FIND v(dout1_0) AT=1000.025n

* CHECK dout1_1 Vdout1_1ck199 = 0.9 time = 1000
.meas tran vdout1_1ck199 FIND v(dout1_1) AT=1000.025n

* CHECK dout1_2 Vdout1_2ck199 = 0 time = 1000
.meas tran vdout1_2ck199 FIND v(dout1_2) AT=1000.025n

* CHECK dout1_3 Vdout1_3ck199 = 0 time = 1000
.meas tran vdout1_3ck199 FIND v(dout1_3) AT=1000.025n

* CHECK dout1_4 Vdout1_4ck199 = 0 time = 1000
.meas tran vdout1_4ck199 FIND v(dout1_4) AT=1000.025n

* CHECK dout1_5 Vdout1_5ck199 = 0 time = 1000
.meas tran vdout1_5ck199 FIND v(dout1_5) AT=1000.025n

* CHECK dout1_6 Vdout1_6ck199 = 0.9 time = 1000
.meas tran vdout1_6ck199 FIND v(dout1_6) AT=1000.025n

* CHECK dout1_7 Vdout1_7ck199 = 0 time = 1000
.meas tran vdout1_7ck199 FIND v(dout1_7) AT=1000.025n

* CHECK dout1_8 Vdout1_8ck199 = 0 time = 1000
.meas tran vdout1_8ck199 FIND v(dout1_8) AT=1000.025n

* CHECK dout1_9 Vdout1_9ck199 = 0.9 time = 1000
.meas tran vdout1_9ck199 FIND v(dout1_9) AT=1000.025n

* CHECK dout1_10 Vdout1_10ck199 = 0 time = 1000
.meas tran vdout1_10ck199 FIND v(dout1_10) AT=1000.025n

* CHECK dout1_11 Vdout1_11ck199 = 0.9 time = 1000
.meas tran vdout1_11ck199 FIND v(dout1_11) AT=1000.025n

* CHECK dout1_12 Vdout1_12ck199 = 0 time = 1000
.meas tran vdout1_12ck199 FIND v(dout1_12) AT=1000.025n

* CHECK dout1_13 Vdout1_13ck199 = 0 time = 1000
.meas tran vdout1_13ck199 FIND v(dout1_13) AT=1000.025n

* CHECK dout1_14 Vdout1_14ck199 = 0.9 time = 1000
.meas tran vdout1_14ck199 FIND v(dout1_14) AT=1000.025n

* CHECK dout1_15 Vdout1_15ck199 = 0 time = 1000
.meas tran vdout1_15ck199 FIND v(dout1_15) AT=1000.025n

* CHECK dout1_16 Vdout1_16ck199 = 0.9 time = 1000
.meas tran vdout1_16ck199 FIND v(dout1_16) AT=1000.025n

* CHECK dout1_17 Vdout1_17ck199 = 0.9 time = 1000
.meas tran vdout1_17ck199 FIND v(dout1_17) AT=1000.025n

* CHECK dout1_18 Vdout1_18ck199 = 0 time = 1000
.meas tran vdout1_18ck199 FIND v(dout1_18) AT=1000.025n

* CHECK dout1_19 Vdout1_19ck199 = 0 time = 1000
.meas tran vdout1_19ck199 FIND v(dout1_19) AT=1000.025n

* CHECK dout1_20 Vdout1_20ck199 = 0 time = 1000
.meas tran vdout1_20ck199 FIND v(dout1_20) AT=1000.025n

* CHECK dout1_21 Vdout1_21ck199 = 0.9 time = 1000
.meas tran vdout1_21ck199 FIND v(dout1_21) AT=1000.025n

* CHECK dout1_22 Vdout1_22ck199 = 0.9 time = 1000
.meas tran vdout1_22ck199 FIND v(dout1_22) AT=1000.025n

* CHECK dout1_23 Vdout1_23ck199 = 0.9 time = 1000
.meas tran vdout1_23ck199 FIND v(dout1_23) AT=1000.025n

* CHECK dout1_24 Vdout1_24ck199 = 0.9 time = 1000
.meas tran vdout1_24ck199 FIND v(dout1_24) AT=1000.025n

* CHECK dout1_25 Vdout1_25ck199 = 0.9 time = 1000
.meas tran vdout1_25ck199 FIND v(dout1_25) AT=1000.025n

* CHECK dout1_26 Vdout1_26ck199 = 0.9 time = 1000
.meas tran vdout1_26ck199 FIND v(dout1_26) AT=1000.025n

* CHECK dout1_27 Vdout1_27ck199 = 0.9 time = 1000
.meas tran vdout1_27ck199 FIND v(dout1_27) AT=1000.025n

* CHECK dout1_28 Vdout1_28ck199 = 0 time = 1000
.meas tran vdout1_28ck199 FIND v(dout1_28) AT=1000.025n

* CHECK dout1_29 Vdout1_29ck199 = 0.9 time = 1000
.meas tran vdout1_29ck199 FIND v(dout1_29) AT=1000.025n

* CHECK dout1_30 Vdout1_30ck199 = 0 time = 1000
.meas tran vdout1_30ck199 FIND v(dout1_30) AT=1000.025n

* CHECK dout1_31 Vdout1_31ck199 = 0 time = 1000
.meas tran vdout1_31ck199 FIND v(dout1_31) AT=1000.025n

* CHECK dout1_32 Vdout1_32ck199 = 0.9 time = 1000
.meas tran vdout1_32ck199 FIND v(dout1_32) AT=1000.025n

* CHECK dout1_33 Vdout1_33ck199 = 0 time = 1000
.meas tran vdout1_33ck199 FIND v(dout1_33) AT=1000.025n

* CHECK dout1_34 Vdout1_34ck199 = 0.9 time = 1000
.meas tran vdout1_34ck199 FIND v(dout1_34) AT=1000.025n

* CHECK dout1_35 Vdout1_35ck199 = 0.9 time = 1000
.meas tran vdout1_35ck199 FIND v(dout1_35) AT=1000.025n

* CHECK dout1_36 Vdout1_36ck199 = 0.9 time = 1000
.meas tran vdout1_36ck199 FIND v(dout1_36) AT=1000.025n

* CHECK dout1_37 Vdout1_37ck199 = 0.9 time = 1000
.meas tran vdout1_37ck199 FIND v(dout1_37) AT=1000.025n

* CHECK dout1_38 Vdout1_38ck199 = 0 time = 1000
.meas tran vdout1_38ck199 FIND v(dout1_38) AT=1000.025n

* CHECK dout1_39 Vdout1_39ck199 = 0.9 time = 1000
.meas tran vdout1_39ck199 FIND v(dout1_39) AT=1000.025n

* CHECK dout1_40 Vdout1_40ck199 = 0 time = 1000
.meas tran vdout1_40ck199 FIND v(dout1_40) AT=1000.025n

* CHECK dout1_41 Vdout1_41ck199 = 0 time = 1000
.meas tran vdout1_41ck199 FIND v(dout1_41) AT=1000.025n

* CHECK dout1_42 Vdout1_42ck199 = 0.9 time = 1000
.meas tran vdout1_42ck199 FIND v(dout1_42) AT=1000.025n

* CHECK dout1_43 Vdout1_43ck199 = 0 time = 1000
.meas tran vdout1_43ck199 FIND v(dout1_43) AT=1000.025n

* CHECK dout1_44 Vdout1_44ck199 = 0 time = 1000
.meas tran vdout1_44ck199 FIND v(dout1_44) AT=1000.025n

* CHECK dout1_45 Vdout1_45ck199 = 0.9 time = 1000
.meas tran vdout1_45ck199 FIND v(dout1_45) AT=1000.025n

* CHECK dout1_46 Vdout1_46ck199 = 0 time = 1000
.meas tran vdout1_46ck199 FIND v(dout1_46) AT=1000.025n

* CHECK dout1_47 Vdout1_47ck199 = 0 time = 1000
.meas tran vdout1_47ck199 FIND v(dout1_47) AT=1000.025n

* CHECK dout1_48 Vdout1_48ck199 = 0 time = 1000
.meas tran vdout1_48ck199 FIND v(dout1_48) AT=1000.025n

* CHECK dout1_49 Vdout1_49ck199 = 0 time = 1000
.meas tran vdout1_49ck199 FIND v(dout1_49) AT=1000.025n

* CHECK dout1_50 Vdout1_50ck199 = 0.9 time = 1000
.meas tran vdout1_50ck199 FIND v(dout1_50) AT=1000.025n

* CHECK dout1_51 Vdout1_51ck199 = 0 time = 1000
.meas tran vdout1_51ck199 FIND v(dout1_51) AT=1000.025n

* CHECK dout1_52 Vdout1_52ck199 = 0 time = 1000
.meas tran vdout1_52ck199 FIND v(dout1_52) AT=1000.025n

* CHECK dout1_53 Vdout1_53ck199 = 0.9 time = 1000
.meas tran vdout1_53ck199 FIND v(dout1_53) AT=1000.025n

* CHECK dout1_54 Vdout1_54ck199 = 0 time = 1000
.meas tran vdout1_54ck199 FIND v(dout1_54) AT=1000.025n

* CHECK dout1_55 Vdout1_55ck199 = 0.9 time = 1000
.meas tran vdout1_55ck199 FIND v(dout1_55) AT=1000.025n

* CHECK dout1_56 Vdout1_56ck199 = 0.9 time = 1000
.meas tran vdout1_56ck199 FIND v(dout1_56) AT=1000.025n

* CHECK dout1_57 Vdout1_57ck199 = 0.9 time = 1000
.meas tran vdout1_57ck199 FIND v(dout1_57) AT=1000.025n

* CHECK dout1_58 Vdout1_58ck199 = 0 time = 1000
.meas tran vdout1_58ck199 FIND v(dout1_58) AT=1000.025n

* CHECK dout1_59 Vdout1_59ck199 = 0 time = 1000
.meas tran vdout1_59ck199 FIND v(dout1_59) AT=1000.025n

* CHECK dout1_60 Vdout1_60ck199 = 0.9 time = 1000
.meas tran vdout1_60ck199 FIND v(dout1_60) AT=1000.025n

* CHECK dout1_61 Vdout1_61ck199 = 0.9 time = 1000
.meas tran vdout1_61ck199 FIND v(dout1_61) AT=1000.025n

* CHECK dout1_62 Vdout1_62ck199 = 0 time = 1000
.meas tran vdout1_62ck199 FIND v(dout1_62) AT=1000.025n

* CHECK dout1_63 Vdout1_63ck199 = 0.9 time = 1000
.meas tran vdout1_63ck199 FIND v(dout1_63) AT=1000.025n

* CHECK dout1_64 Vdout1_64ck199 = 0 time = 1000
.meas tran vdout1_64ck199 FIND v(dout1_64) AT=1000.025n

* CHECK dout1_65 Vdout1_65ck199 = 0.9 time = 1000
.meas tran vdout1_65ck199 FIND v(dout1_65) AT=1000.025n

* CHECK dout1_66 Vdout1_66ck199 = 0.9 time = 1000
.meas tran vdout1_66ck199 FIND v(dout1_66) AT=1000.025n

* CHECK dout1_67 Vdout1_67ck199 = 0.9 time = 1000
.meas tran vdout1_67ck199 FIND v(dout1_67) AT=1000.025n

* CHECK dout1_68 Vdout1_68ck199 = 0.9 time = 1000
.meas tran vdout1_68ck199 FIND v(dout1_68) AT=1000.025n

* CHECK dout1_69 Vdout1_69ck199 = 0.9 time = 1000
.meas tran vdout1_69ck199 FIND v(dout1_69) AT=1000.025n

* CHECK dout1_70 Vdout1_70ck199 = 0.9 time = 1000
.meas tran vdout1_70ck199 FIND v(dout1_70) AT=1000.025n

* CHECK dout1_71 Vdout1_71ck199 = 0 time = 1000
.meas tran vdout1_71ck199 FIND v(dout1_71) AT=1000.025n

* CHECK dout1_72 Vdout1_72ck199 = 0 time = 1000
.meas tran vdout1_72ck199 FIND v(dout1_72) AT=1000.025n

* CHECK dout1_73 Vdout1_73ck199 = 0.9 time = 1000
.meas tran vdout1_73ck199 FIND v(dout1_73) AT=1000.025n

* CHECK dout1_74 Vdout1_74ck199 = 0.9 time = 1000
.meas tran vdout1_74ck199 FIND v(dout1_74) AT=1000.025n

* CHECK dout1_75 Vdout1_75ck199 = 0.9 time = 1000
.meas tran vdout1_75ck199 FIND v(dout1_75) AT=1000.025n

* CHECK dout1_76 Vdout1_76ck199 = 0 time = 1000
.meas tran vdout1_76ck199 FIND v(dout1_76) AT=1000.025n

* CHECK dout1_77 Vdout1_77ck199 = 0.9 time = 1000
.meas tran vdout1_77ck199 FIND v(dout1_77) AT=1000.025n

* CHECK dout1_78 Vdout1_78ck199 = 0 time = 1000
.meas tran vdout1_78ck199 FIND v(dout1_78) AT=1000.025n

* CHECK dout1_79 Vdout1_79ck199 = 0 time = 1000
.meas tran vdout1_79ck199 FIND v(dout1_79) AT=1000.025n

* CHECK dout1_80 Vdout1_80ck199 = 0 time = 1000
.meas tran vdout1_80ck199 FIND v(dout1_80) AT=1000.025n

* CHECK dout1_81 Vdout1_81ck199 = 0.9 time = 1000
.meas tran vdout1_81ck199 FIND v(dout1_81) AT=1000.025n

* CHECK dout1_82 Vdout1_82ck199 = 0.9 time = 1000
.meas tran vdout1_82ck199 FIND v(dout1_82) AT=1000.025n

* CHECK dout1_83 Vdout1_83ck199 = 0 time = 1000
.meas tran vdout1_83ck199 FIND v(dout1_83) AT=1000.025n

* CHECK dout1_84 Vdout1_84ck199 = 0.9 time = 1000
.meas tran vdout1_84ck199 FIND v(dout1_84) AT=1000.025n

* CHECK dout1_85 Vdout1_85ck199 = 0 time = 1000
.meas tran vdout1_85ck199 FIND v(dout1_85) AT=1000.025n

* CHECK dout1_86 Vdout1_86ck199 = 0.9 time = 1000
.meas tran vdout1_86ck199 FIND v(dout1_86) AT=1000.025n

* CHECK dout1_87 Vdout1_87ck199 = 0 time = 1000
.meas tran vdout1_87ck199 FIND v(dout1_87) AT=1000.025n

* CHECK dout1_88 Vdout1_88ck199 = 0.9 time = 1000
.meas tran vdout1_88ck199 FIND v(dout1_88) AT=1000.025n

* CHECK dout1_89 Vdout1_89ck199 = 0 time = 1000
.meas tran vdout1_89ck199 FIND v(dout1_89) AT=1000.025n

* CHECK dout1_90 Vdout1_90ck199 = 0.9 time = 1000
.meas tran vdout1_90ck199 FIND v(dout1_90) AT=1000.025n

* CHECK dout1_91 Vdout1_91ck199 = 0 time = 1000
.meas tran vdout1_91ck199 FIND v(dout1_91) AT=1000.025n

* CHECK dout1_92 Vdout1_92ck199 = 0 time = 1000
.meas tran vdout1_92ck199 FIND v(dout1_92) AT=1000.025n

* CHECK dout1_93 Vdout1_93ck199 = 0 time = 1000
.meas tran vdout1_93ck199 FIND v(dout1_93) AT=1000.025n

* CHECK dout1_94 Vdout1_94ck199 = 0 time = 1000
.meas tran vdout1_94ck199 FIND v(dout1_94) AT=1000.025n

* CHECK dout1_95 Vdout1_95ck199 = 0 time = 1000
.meas tran vdout1_95ck199 FIND v(dout1_95) AT=1000.025n

* CHECK dout1_96 Vdout1_96ck199 = 0 time = 1000
.meas tran vdout1_96ck199 FIND v(dout1_96) AT=1000.025n

* CHECK dout1_97 Vdout1_97ck199 = 0.9 time = 1000
.meas tran vdout1_97ck199 FIND v(dout1_97) AT=1000.025n

* CHECK dout1_98 Vdout1_98ck199 = 0.9 time = 1000
.meas tran vdout1_98ck199 FIND v(dout1_98) AT=1000.025n

* CHECK dout1_99 Vdout1_99ck199 = 0.9 time = 1000
.meas tran vdout1_99ck199 FIND v(dout1_99) AT=1000.025n

* CHECK dout1_100 Vdout1_100ck199 = 0 time = 1000
.meas tran vdout1_100ck199 FIND v(dout1_100) AT=1000.025n

* CHECK dout1_101 Vdout1_101ck199 = 0.9 time = 1000
.meas tran vdout1_101ck199 FIND v(dout1_101) AT=1000.025n

* CHECK dout1_102 Vdout1_102ck199 = 0.9 time = 1000
.meas tran vdout1_102ck199 FIND v(dout1_102) AT=1000.025n

* CHECK dout1_103 Vdout1_103ck199 = 0 time = 1000
.meas tran vdout1_103ck199 FIND v(dout1_103) AT=1000.025n

* CHECK dout1_104 Vdout1_104ck199 = 0 time = 1000
.meas tran vdout1_104ck199 FIND v(dout1_104) AT=1000.025n

* CHECK dout1_105 Vdout1_105ck199 = 0.9 time = 1000
.meas tran vdout1_105ck199 FIND v(dout1_105) AT=1000.025n

* CHECK dout1_106 Vdout1_106ck199 = 0 time = 1000
.meas tran vdout1_106ck199 FIND v(dout1_106) AT=1000.025n

* CHECK dout1_107 Vdout1_107ck199 = 0 time = 1000
.meas tran vdout1_107ck199 FIND v(dout1_107) AT=1000.025n

* CHECK dout1_108 Vdout1_108ck199 = 0 time = 1000
.meas tran vdout1_108ck199 FIND v(dout1_108) AT=1000.025n

* CHECK dout1_109 Vdout1_109ck199 = 0 time = 1000
.meas tran vdout1_109ck199 FIND v(dout1_109) AT=1000.025n

* CHECK dout1_110 Vdout1_110ck199 = 0.9 time = 1000
.meas tran vdout1_110ck199 FIND v(dout1_110) AT=1000.025n

* CHECK dout1_111 Vdout1_111ck199 = 0 time = 1000
.meas tran vdout1_111ck199 FIND v(dout1_111) AT=1000.025n

* CHECK dout1_112 Vdout1_112ck199 = 0.9 time = 1000
.meas tran vdout1_112ck199 FIND v(dout1_112) AT=1000.025n

* CHECK dout1_113 Vdout1_113ck199 = 0 time = 1000
.meas tran vdout1_113ck199 FIND v(dout1_113) AT=1000.025n

* CHECK dout1_114 Vdout1_114ck199 = 0.9 time = 1000
.meas tran vdout1_114ck199 FIND v(dout1_114) AT=1000.025n

* CHECK dout1_115 Vdout1_115ck199 = 0.9 time = 1000
.meas tran vdout1_115ck199 FIND v(dout1_115) AT=1000.025n

* CHECK dout1_116 Vdout1_116ck199 = 0.9 time = 1000
.meas tran vdout1_116ck199 FIND v(dout1_116) AT=1000.025n

* CHECK dout1_117 Vdout1_117ck199 = 0.9 time = 1000
.meas tran vdout1_117ck199 FIND v(dout1_117) AT=1000.025n

* CHECK dout1_118 Vdout1_118ck199 = 0.9 time = 1000
.meas tran vdout1_118ck199 FIND v(dout1_118) AT=1000.025n

* CHECK dout1_119 Vdout1_119ck199 = 0 time = 1000
.meas tran vdout1_119ck199 FIND v(dout1_119) AT=1000.025n

* CHECK dout1_0 Vdout1_0ck200 = 0.9 time = 1005
.meas tran vdout1_0ck200 FIND v(dout1_0) AT=1005.025n

* CHECK dout1_1 Vdout1_1ck200 = 0.9 time = 1005
.meas tran vdout1_1ck200 FIND v(dout1_1) AT=1005.025n

* CHECK dout1_2 Vdout1_2ck200 = 0.9 time = 1005
.meas tran vdout1_2ck200 FIND v(dout1_2) AT=1005.025n

* CHECK dout1_3 Vdout1_3ck200 = 0 time = 1005
.meas tran vdout1_3ck200 FIND v(dout1_3) AT=1005.025n

* CHECK dout1_4 Vdout1_4ck200 = 0.9 time = 1005
.meas tran vdout1_4ck200 FIND v(dout1_4) AT=1005.025n

* CHECK dout1_5 Vdout1_5ck200 = 0 time = 1005
.meas tran vdout1_5ck200 FIND v(dout1_5) AT=1005.025n

* CHECK dout1_6 Vdout1_6ck200 = 0.9 time = 1005
.meas tran vdout1_6ck200 FIND v(dout1_6) AT=1005.025n

* CHECK dout1_7 Vdout1_7ck200 = 0 time = 1005
.meas tran vdout1_7ck200 FIND v(dout1_7) AT=1005.025n

* CHECK dout1_8 Vdout1_8ck200 = 0 time = 1005
.meas tran vdout1_8ck200 FIND v(dout1_8) AT=1005.025n

* CHECK dout1_9 Vdout1_9ck200 = 0.9 time = 1005
.meas tran vdout1_9ck200 FIND v(dout1_9) AT=1005.025n

* CHECK dout1_10 Vdout1_10ck200 = 0 time = 1005
.meas tran vdout1_10ck200 FIND v(dout1_10) AT=1005.025n

* CHECK dout1_11 Vdout1_11ck200 = 0 time = 1005
.meas tran vdout1_11ck200 FIND v(dout1_11) AT=1005.025n

* CHECK dout1_12 Vdout1_12ck200 = 0 time = 1005
.meas tran vdout1_12ck200 FIND v(dout1_12) AT=1005.025n

* CHECK dout1_13 Vdout1_13ck200 = 0 time = 1005
.meas tran vdout1_13ck200 FIND v(dout1_13) AT=1005.025n

* CHECK dout1_14 Vdout1_14ck200 = 0 time = 1005
.meas tran vdout1_14ck200 FIND v(dout1_14) AT=1005.025n

* CHECK dout1_15 Vdout1_15ck200 = 0 time = 1005
.meas tran vdout1_15ck200 FIND v(dout1_15) AT=1005.025n

* CHECK dout1_16 Vdout1_16ck200 = 0.9 time = 1005
.meas tran vdout1_16ck200 FIND v(dout1_16) AT=1005.025n

* CHECK dout1_17 Vdout1_17ck200 = 0 time = 1005
.meas tran vdout1_17ck200 FIND v(dout1_17) AT=1005.025n

* CHECK dout1_18 Vdout1_18ck200 = 0.9 time = 1005
.meas tran vdout1_18ck200 FIND v(dout1_18) AT=1005.025n

* CHECK dout1_19 Vdout1_19ck200 = 0.9 time = 1005
.meas tran vdout1_19ck200 FIND v(dout1_19) AT=1005.025n

* CHECK dout1_20 Vdout1_20ck200 = 0 time = 1005
.meas tran vdout1_20ck200 FIND v(dout1_20) AT=1005.025n

* CHECK dout1_21 Vdout1_21ck200 = 0.9 time = 1005
.meas tran vdout1_21ck200 FIND v(dout1_21) AT=1005.025n

* CHECK dout1_22 Vdout1_22ck200 = 0.9 time = 1005
.meas tran vdout1_22ck200 FIND v(dout1_22) AT=1005.025n

* CHECK dout1_23 Vdout1_23ck200 = 0.9 time = 1005
.meas tran vdout1_23ck200 FIND v(dout1_23) AT=1005.025n

* CHECK dout1_24 Vdout1_24ck200 = 0.9 time = 1005
.meas tran vdout1_24ck200 FIND v(dout1_24) AT=1005.025n

* CHECK dout1_25 Vdout1_25ck200 = 0 time = 1005
.meas tran vdout1_25ck200 FIND v(dout1_25) AT=1005.025n

* CHECK dout1_26 Vdout1_26ck200 = 0 time = 1005
.meas tran vdout1_26ck200 FIND v(dout1_26) AT=1005.025n

* CHECK dout1_27 Vdout1_27ck200 = 0 time = 1005
.meas tran vdout1_27ck200 FIND v(dout1_27) AT=1005.025n

* CHECK dout1_28 Vdout1_28ck200 = 0.9 time = 1005
.meas tran vdout1_28ck200 FIND v(dout1_28) AT=1005.025n

* CHECK dout1_29 Vdout1_29ck200 = 0.9 time = 1005
.meas tran vdout1_29ck200 FIND v(dout1_29) AT=1005.025n

* CHECK dout1_30 Vdout1_30ck200 = 0 time = 1005
.meas tran vdout1_30ck200 FIND v(dout1_30) AT=1005.025n

* CHECK dout1_31 Vdout1_31ck200 = 0 time = 1005
.meas tran vdout1_31ck200 FIND v(dout1_31) AT=1005.025n

* CHECK dout1_32 Vdout1_32ck200 = 0 time = 1005
.meas tran vdout1_32ck200 FIND v(dout1_32) AT=1005.025n

* CHECK dout1_33 Vdout1_33ck200 = 0 time = 1005
.meas tran vdout1_33ck200 FIND v(dout1_33) AT=1005.025n

* CHECK dout1_34 Vdout1_34ck200 = 0 time = 1005
.meas tran vdout1_34ck200 FIND v(dout1_34) AT=1005.025n

* CHECK dout1_35 Vdout1_35ck200 = 0 time = 1005
.meas tran vdout1_35ck200 FIND v(dout1_35) AT=1005.025n

* CHECK dout1_36 Vdout1_36ck200 = 0.9 time = 1005
.meas tran vdout1_36ck200 FIND v(dout1_36) AT=1005.025n

* CHECK dout1_37 Vdout1_37ck200 = 0 time = 1005
.meas tran vdout1_37ck200 FIND v(dout1_37) AT=1005.025n

* CHECK dout1_38 Vdout1_38ck200 = 0.9 time = 1005
.meas tran vdout1_38ck200 FIND v(dout1_38) AT=1005.025n

* CHECK dout1_39 Vdout1_39ck200 = 0.9 time = 1005
.meas tran vdout1_39ck200 FIND v(dout1_39) AT=1005.025n

* CHECK dout1_40 Vdout1_40ck200 = 0.9 time = 1005
.meas tran vdout1_40ck200 FIND v(dout1_40) AT=1005.025n

* CHECK dout1_41 Vdout1_41ck200 = 0.9 time = 1005
.meas tran vdout1_41ck200 FIND v(dout1_41) AT=1005.025n

* CHECK dout1_42 Vdout1_42ck200 = 0 time = 1005
.meas tran vdout1_42ck200 FIND v(dout1_42) AT=1005.025n

* CHECK dout1_43 Vdout1_43ck200 = 0.9 time = 1005
.meas tran vdout1_43ck200 FIND v(dout1_43) AT=1005.025n

* CHECK dout1_44 Vdout1_44ck200 = 0.9 time = 1005
.meas tran vdout1_44ck200 FIND v(dout1_44) AT=1005.025n

* CHECK dout1_45 Vdout1_45ck200 = 0 time = 1005
.meas tran vdout1_45ck200 FIND v(dout1_45) AT=1005.025n

* CHECK dout1_46 Vdout1_46ck200 = 0 time = 1005
.meas tran vdout1_46ck200 FIND v(dout1_46) AT=1005.025n

* CHECK dout1_47 Vdout1_47ck200 = 0.9 time = 1005
.meas tran vdout1_47ck200 FIND v(dout1_47) AT=1005.025n

* CHECK dout1_48 Vdout1_48ck200 = 0 time = 1005
.meas tran vdout1_48ck200 FIND v(dout1_48) AT=1005.025n

* CHECK dout1_49 Vdout1_49ck200 = 0.9 time = 1005
.meas tran vdout1_49ck200 FIND v(dout1_49) AT=1005.025n

* CHECK dout1_50 Vdout1_50ck200 = 0 time = 1005
.meas tran vdout1_50ck200 FIND v(dout1_50) AT=1005.025n

* CHECK dout1_51 Vdout1_51ck200 = 0 time = 1005
.meas tran vdout1_51ck200 FIND v(dout1_51) AT=1005.025n

* CHECK dout1_52 Vdout1_52ck200 = 0.9 time = 1005
.meas tran vdout1_52ck200 FIND v(dout1_52) AT=1005.025n

* CHECK dout1_53 Vdout1_53ck200 = 0 time = 1005
.meas tran vdout1_53ck200 FIND v(dout1_53) AT=1005.025n

* CHECK dout1_54 Vdout1_54ck200 = 0.9 time = 1005
.meas tran vdout1_54ck200 FIND v(dout1_54) AT=1005.025n

* CHECK dout1_55 Vdout1_55ck200 = 0 time = 1005
.meas tran vdout1_55ck200 FIND v(dout1_55) AT=1005.025n

* CHECK dout1_56 Vdout1_56ck200 = 0 time = 1005
.meas tran vdout1_56ck200 FIND v(dout1_56) AT=1005.025n

* CHECK dout1_57 Vdout1_57ck200 = 0 time = 1005
.meas tran vdout1_57ck200 FIND v(dout1_57) AT=1005.025n

* CHECK dout1_58 Vdout1_58ck200 = 0.9 time = 1005
.meas tran vdout1_58ck200 FIND v(dout1_58) AT=1005.025n

* CHECK dout1_59 Vdout1_59ck200 = 0 time = 1005
.meas tran vdout1_59ck200 FIND v(dout1_59) AT=1005.025n

* CHECK dout1_60 Vdout1_60ck200 = 0.9 time = 1005
.meas tran vdout1_60ck200 FIND v(dout1_60) AT=1005.025n

* CHECK dout1_61 Vdout1_61ck200 = 0 time = 1005
.meas tran vdout1_61ck200 FIND v(dout1_61) AT=1005.025n

* CHECK dout1_62 Vdout1_62ck200 = 0.9 time = 1005
.meas tran vdout1_62ck200 FIND v(dout1_62) AT=1005.025n

* CHECK dout1_63 Vdout1_63ck200 = 0 time = 1005
.meas tran vdout1_63ck200 FIND v(dout1_63) AT=1005.025n

* CHECK dout1_64 Vdout1_64ck200 = 0.9 time = 1005
.meas tran vdout1_64ck200 FIND v(dout1_64) AT=1005.025n

* CHECK dout1_65 Vdout1_65ck200 = 0 time = 1005
.meas tran vdout1_65ck200 FIND v(dout1_65) AT=1005.025n

* CHECK dout1_66 Vdout1_66ck200 = 0 time = 1005
.meas tran vdout1_66ck200 FIND v(dout1_66) AT=1005.025n

* CHECK dout1_67 Vdout1_67ck200 = 0 time = 1005
.meas tran vdout1_67ck200 FIND v(dout1_67) AT=1005.025n

* CHECK dout1_68 Vdout1_68ck200 = 0.9 time = 1005
.meas tran vdout1_68ck200 FIND v(dout1_68) AT=1005.025n

* CHECK dout1_69 Vdout1_69ck200 = 0 time = 1005
.meas tran vdout1_69ck200 FIND v(dout1_69) AT=1005.025n

* CHECK dout1_70 Vdout1_70ck200 = 0.9 time = 1005
.meas tran vdout1_70ck200 FIND v(dout1_70) AT=1005.025n

* CHECK dout1_71 Vdout1_71ck200 = 0 time = 1005
.meas tran vdout1_71ck200 FIND v(dout1_71) AT=1005.025n

* CHECK dout1_72 Vdout1_72ck200 = 0 time = 1005
.meas tran vdout1_72ck200 FIND v(dout1_72) AT=1005.025n

* CHECK dout1_73 Vdout1_73ck200 = 0.9 time = 1005
.meas tran vdout1_73ck200 FIND v(dout1_73) AT=1005.025n

* CHECK dout1_74 Vdout1_74ck200 = 0 time = 1005
.meas tran vdout1_74ck200 FIND v(dout1_74) AT=1005.025n

* CHECK dout1_75 Vdout1_75ck200 = 0 time = 1005
.meas tran vdout1_75ck200 FIND v(dout1_75) AT=1005.025n

* CHECK dout1_76 Vdout1_76ck200 = 0.9 time = 1005
.meas tran vdout1_76ck200 FIND v(dout1_76) AT=1005.025n

* CHECK dout1_77 Vdout1_77ck200 = 0.9 time = 1005
.meas tran vdout1_77ck200 FIND v(dout1_77) AT=1005.025n

* CHECK dout1_78 Vdout1_78ck200 = 0 time = 1005
.meas tran vdout1_78ck200 FIND v(dout1_78) AT=1005.025n

* CHECK dout1_79 Vdout1_79ck200 = 0 time = 1005
.meas tran vdout1_79ck200 FIND v(dout1_79) AT=1005.025n

* CHECK dout1_80 Vdout1_80ck200 = 0 time = 1005
.meas tran vdout1_80ck200 FIND v(dout1_80) AT=1005.025n

* CHECK dout1_81 Vdout1_81ck200 = 0.9 time = 1005
.meas tran vdout1_81ck200 FIND v(dout1_81) AT=1005.025n

* CHECK dout1_82 Vdout1_82ck200 = 0 time = 1005
.meas tran vdout1_82ck200 FIND v(dout1_82) AT=1005.025n

* CHECK dout1_83 Vdout1_83ck200 = 0 time = 1005
.meas tran vdout1_83ck200 FIND v(dout1_83) AT=1005.025n

* CHECK dout1_84 Vdout1_84ck200 = 0 time = 1005
.meas tran vdout1_84ck200 FIND v(dout1_84) AT=1005.025n

* CHECK dout1_85 Vdout1_85ck200 = 0.9 time = 1005
.meas tran vdout1_85ck200 FIND v(dout1_85) AT=1005.025n

* CHECK dout1_86 Vdout1_86ck200 = 0.9 time = 1005
.meas tran vdout1_86ck200 FIND v(dout1_86) AT=1005.025n

* CHECK dout1_87 Vdout1_87ck200 = 0.9 time = 1005
.meas tran vdout1_87ck200 FIND v(dout1_87) AT=1005.025n

* CHECK dout1_88 Vdout1_88ck200 = 0.9 time = 1005
.meas tran vdout1_88ck200 FIND v(dout1_88) AT=1005.025n

* CHECK dout1_89 Vdout1_89ck200 = 0 time = 1005
.meas tran vdout1_89ck200 FIND v(dout1_89) AT=1005.025n

* CHECK dout1_90 Vdout1_90ck200 = 0.9 time = 1005
.meas tran vdout1_90ck200 FIND v(dout1_90) AT=1005.025n

* CHECK dout1_91 Vdout1_91ck200 = 0.9 time = 1005
.meas tran vdout1_91ck200 FIND v(dout1_91) AT=1005.025n

* CHECK dout1_92 Vdout1_92ck200 = 0.9 time = 1005
.meas tran vdout1_92ck200 FIND v(dout1_92) AT=1005.025n

* CHECK dout1_93 Vdout1_93ck200 = 0 time = 1005
.meas tran vdout1_93ck200 FIND v(dout1_93) AT=1005.025n

* CHECK dout1_94 Vdout1_94ck200 = 0.9 time = 1005
.meas tran vdout1_94ck200 FIND v(dout1_94) AT=1005.025n

* CHECK dout1_95 Vdout1_95ck200 = 0.9 time = 1005
.meas tran vdout1_95ck200 FIND v(dout1_95) AT=1005.025n

* CHECK dout1_96 Vdout1_96ck200 = 0 time = 1005
.meas tran vdout1_96ck200 FIND v(dout1_96) AT=1005.025n

* CHECK dout1_97 Vdout1_97ck200 = 0 time = 1005
.meas tran vdout1_97ck200 FIND v(dout1_97) AT=1005.025n

* CHECK dout1_98 Vdout1_98ck200 = 0 time = 1005
.meas tran vdout1_98ck200 FIND v(dout1_98) AT=1005.025n

* CHECK dout1_99 Vdout1_99ck200 = 0.9 time = 1005
.meas tran vdout1_99ck200 FIND v(dout1_99) AT=1005.025n

* CHECK dout1_100 Vdout1_100ck200 = 0.9 time = 1005
.meas tran vdout1_100ck200 FIND v(dout1_100) AT=1005.025n

* CHECK dout1_101 Vdout1_101ck200 = 0.9 time = 1005
.meas tran vdout1_101ck200 FIND v(dout1_101) AT=1005.025n

* CHECK dout1_102 Vdout1_102ck200 = 0.9 time = 1005
.meas tran vdout1_102ck200 FIND v(dout1_102) AT=1005.025n

* CHECK dout1_103 Vdout1_103ck200 = 0.9 time = 1005
.meas tran vdout1_103ck200 FIND v(dout1_103) AT=1005.025n

* CHECK dout1_104 Vdout1_104ck200 = 0 time = 1005
.meas tran vdout1_104ck200 FIND v(dout1_104) AT=1005.025n

* CHECK dout1_105 Vdout1_105ck200 = 0.9 time = 1005
.meas tran vdout1_105ck200 FIND v(dout1_105) AT=1005.025n

* CHECK dout1_106 Vdout1_106ck200 = 0 time = 1005
.meas tran vdout1_106ck200 FIND v(dout1_106) AT=1005.025n

* CHECK dout1_107 Vdout1_107ck200 = 0 time = 1005
.meas tran vdout1_107ck200 FIND v(dout1_107) AT=1005.025n

* CHECK dout1_108 Vdout1_108ck200 = 0.9 time = 1005
.meas tran vdout1_108ck200 FIND v(dout1_108) AT=1005.025n

* CHECK dout1_109 Vdout1_109ck200 = 0 time = 1005
.meas tran vdout1_109ck200 FIND v(dout1_109) AT=1005.025n

* CHECK dout1_110 Vdout1_110ck200 = 0.9 time = 1005
.meas tran vdout1_110ck200 FIND v(dout1_110) AT=1005.025n

* CHECK dout1_111 Vdout1_111ck200 = 0 time = 1005
.meas tran vdout1_111ck200 FIND v(dout1_111) AT=1005.025n

* CHECK dout1_112 Vdout1_112ck200 = 0 time = 1005
.meas tran vdout1_112ck200 FIND v(dout1_112) AT=1005.025n

* CHECK dout1_113 Vdout1_113ck200 = 0 time = 1005
.meas tran vdout1_113ck200 FIND v(dout1_113) AT=1005.025n

* CHECK dout1_114 Vdout1_114ck200 = 0.9 time = 1005
.meas tran vdout1_114ck200 FIND v(dout1_114) AT=1005.025n

* CHECK dout1_115 Vdout1_115ck200 = 0 time = 1005
.meas tran vdout1_115ck200 FIND v(dout1_115) AT=1005.025n

* CHECK dout1_116 Vdout1_116ck200 = 0 time = 1005
.meas tran vdout1_116ck200 FIND v(dout1_116) AT=1005.025n

* CHECK dout1_117 Vdout1_117ck200 = 0 time = 1005
.meas tran vdout1_117ck200 FIND v(dout1_117) AT=1005.025n

* CHECK dout1_118 Vdout1_118ck200 = 0.9 time = 1005
.meas tran vdout1_118ck200 FIND v(dout1_118) AT=1005.025n

* CHECK dout1_119 Vdout1_119ck200 = 0 time = 1005
.meas tran vdout1_119ck200 FIND v(dout1_119) AT=1005.025n

* CHECK dout1_0 Vdout1_0ck201 = 0 time = 1010
.meas tran vdout1_0ck201 FIND v(dout1_0) AT=1010.025n

* CHECK dout1_1 Vdout1_1ck201 = 0 time = 1010
.meas tran vdout1_1ck201 FIND v(dout1_1) AT=1010.025n

* CHECK dout1_2 Vdout1_2ck201 = 0 time = 1010
.meas tran vdout1_2ck201 FIND v(dout1_2) AT=1010.025n

* CHECK dout1_3 Vdout1_3ck201 = 0 time = 1010
.meas tran vdout1_3ck201 FIND v(dout1_3) AT=1010.025n

* CHECK dout1_4 Vdout1_4ck201 = 0.9 time = 1010
.meas tran vdout1_4ck201 FIND v(dout1_4) AT=1010.025n

* CHECK dout1_5 Vdout1_5ck201 = 0 time = 1010
.meas tran vdout1_5ck201 FIND v(dout1_5) AT=1010.025n

* CHECK dout1_6 Vdout1_6ck201 = 0 time = 1010
.meas tran vdout1_6ck201 FIND v(dout1_6) AT=1010.025n

* CHECK dout1_7 Vdout1_7ck201 = 0.9 time = 1010
.meas tran vdout1_7ck201 FIND v(dout1_7) AT=1010.025n

* CHECK dout1_8 Vdout1_8ck201 = 0.9 time = 1010
.meas tran vdout1_8ck201 FIND v(dout1_8) AT=1010.025n

* CHECK dout1_9 Vdout1_9ck201 = 0.9 time = 1010
.meas tran vdout1_9ck201 FIND v(dout1_9) AT=1010.025n

* CHECK dout1_10 Vdout1_10ck201 = 0 time = 1010
.meas tran vdout1_10ck201 FIND v(dout1_10) AT=1010.025n

* CHECK dout1_11 Vdout1_11ck201 = 0.9 time = 1010
.meas tran vdout1_11ck201 FIND v(dout1_11) AT=1010.025n

* CHECK dout1_12 Vdout1_12ck201 = 0 time = 1010
.meas tran vdout1_12ck201 FIND v(dout1_12) AT=1010.025n

* CHECK dout1_13 Vdout1_13ck201 = 0.9 time = 1010
.meas tran vdout1_13ck201 FIND v(dout1_13) AT=1010.025n

* CHECK dout1_14 Vdout1_14ck201 = 0 time = 1010
.meas tran vdout1_14ck201 FIND v(dout1_14) AT=1010.025n

* CHECK dout1_15 Vdout1_15ck201 = 0.9 time = 1010
.meas tran vdout1_15ck201 FIND v(dout1_15) AT=1010.025n

* CHECK dout1_16 Vdout1_16ck201 = 0 time = 1010
.meas tran vdout1_16ck201 FIND v(dout1_16) AT=1010.025n

* CHECK dout1_17 Vdout1_17ck201 = 0.9 time = 1010
.meas tran vdout1_17ck201 FIND v(dout1_17) AT=1010.025n

* CHECK dout1_18 Vdout1_18ck201 = 0.9 time = 1010
.meas tran vdout1_18ck201 FIND v(dout1_18) AT=1010.025n

* CHECK dout1_19 Vdout1_19ck201 = 0 time = 1010
.meas tran vdout1_19ck201 FIND v(dout1_19) AT=1010.025n

* CHECK dout1_20 Vdout1_20ck201 = 0.9 time = 1010
.meas tran vdout1_20ck201 FIND v(dout1_20) AT=1010.025n

* CHECK dout1_21 Vdout1_21ck201 = 0 time = 1010
.meas tran vdout1_21ck201 FIND v(dout1_21) AT=1010.025n

* CHECK dout1_22 Vdout1_22ck201 = 0 time = 1010
.meas tran vdout1_22ck201 FIND v(dout1_22) AT=1010.025n

* CHECK dout1_23 Vdout1_23ck201 = 0 time = 1010
.meas tran vdout1_23ck201 FIND v(dout1_23) AT=1010.025n

* CHECK dout1_24 Vdout1_24ck201 = 0 time = 1010
.meas tran vdout1_24ck201 FIND v(dout1_24) AT=1010.025n

* CHECK dout1_25 Vdout1_25ck201 = 0 time = 1010
.meas tran vdout1_25ck201 FIND v(dout1_25) AT=1010.025n

* CHECK dout1_26 Vdout1_26ck201 = 0 time = 1010
.meas tran vdout1_26ck201 FIND v(dout1_26) AT=1010.025n

* CHECK dout1_27 Vdout1_27ck201 = 0 time = 1010
.meas tran vdout1_27ck201 FIND v(dout1_27) AT=1010.025n

* CHECK dout1_28 Vdout1_28ck201 = 0 time = 1010
.meas tran vdout1_28ck201 FIND v(dout1_28) AT=1010.025n

* CHECK dout1_29 Vdout1_29ck201 = 0.9 time = 1010
.meas tran vdout1_29ck201 FIND v(dout1_29) AT=1010.025n

* CHECK dout1_30 Vdout1_30ck201 = 0 time = 1010
.meas tran vdout1_30ck201 FIND v(dout1_30) AT=1010.025n

* CHECK dout1_31 Vdout1_31ck201 = 0 time = 1010
.meas tran vdout1_31ck201 FIND v(dout1_31) AT=1010.025n

* CHECK dout1_32 Vdout1_32ck201 = 0 time = 1010
.meas tran vdout1_32ck201 FIND v(dout1_32) AT=1010.025n

* CHECK dout1_33 Vdout1_33ck201 = 0.9 time = 1010
.meas tran vdout1_33ck201 FIND v(dout1_33) AT=1010.025n

* CHECK dout1_34 Vdout1_34ck201 = 0.9 time = 1010
.meas tran vdout1_34ck201 FIND v(dout1_34) AT=1010.025n

* CHECK dout1_35 Vdout1_35ck201 = 0 time = 1010
.meas tran vdout1_35ck201 FIND v(dout1_35) AT=1010.025n

* CHECK dout1_36 Vdout1_36ck201 = 0.9 time = 1010
.meas tran vdout1_36ck201 FIND v(dout1_36) AT=1010.025n

* CHECK dout1_37 Vdout1_37ck201 = 0 time = 1010
.meas tran vdout1_37ck201 FIND v(dout1_37) AT=1010.025n

* CHECK dout1_38 Vdout1_38ck201 = 0.9 time = 1010
.meas tran vdout1_38ck201 FIND v(dout1_38) AT=1010.025n

* CHECK dout1_39 Vdout1_39ck201 = 0.9 time = 1010
.meas tran vdout1_39ck201 FIND v(dout1_39) AT=1010.025n

* CHECK dout1_40 Vdout1_40ck201 = 0.9 time = 1010
.meas tran vdout1_40ck201 FIND v(dout1_40) AT=1010.025n

* CHECK dout1_41 Vdout1_41ck201 = 0.9 time = 1010
.meas tran vdout1_41ck201 FIND v(dout1_41) AT=1010.025n

* CHECK dout1_42 Vdout1_42ck201 = 0 time = 1010
.meas tran vdout1_42ck201 FIND v(dout1_42) AT=1010.025n

* CHECK dout1_43 Vdout1_43ck201 = 0.9 time = 1010
.meas tran vdout1_43ck201 FIND v(dout1_43) AT=1010.025n

* CHECK dout1_44 Vdout1_44ck201 = 0.9 time = 1010
.meas tran vdout1_44ck201 FIND v(dout1_44) AT=1010.025n

* CHECK dout1_45 Vdout1_45ck201 = 0 time = 1010
.meas tran vdout1_45ck201 FIND v(dout1_45) AT=1010.025n

* CHECK dout1_46 Vdout1_46ck201 = 0.9 time = 1010
.meas tran vdout1_46ck201 FIND v(dout1_46) AT=1010.025n

* CHECK dout1_47 Vdout1_47ck201 = 0.9 time = 1010
.meas tran vdout1_47ck201 FIND v(dout1_47) AT=1010.025n

* CHECK dout1_48 Vdout1_48ck201 = 0.9 time = 1010
.meas tran vdout1_48ck201 FIND v(dout1_48) AT=1010.025n

* CHECK dout1_49 Vdout1_49ck201 = 0.9 time = 1010
.meas tran vdout1_49ck201 FIND v(dout1_49) AT=1010.025n

* CHECK dout1_50 Vdout1_50ck201 = 0 time = 1010
.meas tran vdout1_50ck201 FIND v(dout1_50) AT=1010.025n

* CHECK dout1_51 Vdout1_51ck201 = 0 time = 1010
.meas tran vdout1_51ck201 FIND v(dout1_51) AT=1010.025n

* CHECK dout1_52 Vdout1_52ck201 = 0.9 time = 1010
.meas tran vdout1_52ck201 FIND v(dout1_52) AT=1010.025n

* CHECK dout1_53 Vdout1_53ck201 = 0 time = 1010
.meas tran vdout1_53ck201 FIND v(dout1_53) AT=1010.025n

* CHECK dout1_54 Vdout1_54ck201 = 0.9 time = 1010
.meas tran vdout1_54ck201 FIND v(dout1_54) AT=1010.025n

* CHECK dout1_55 Vdout1_55ck201 = 0.9 time = 1010
.meas tran vdout1_55ck201 FIND v(dout1_55) AT=1010.025n

* CHECK dout1_56 Vdout1_56ck201 = 0.9 time = 1010
.meas tran vdout1_56ck201 FIND v(dout1_56) AT=1010.025n

* CHECK dout1_57 Vdout1_57ck201 = 0 time = 1010
.meas tran vdout1_57ck201 FIND v(dout1_57) AT=1010.025n

* CHECK dout1_58 Vdout1_58ck201 = 0.9 time = 1010
.meas tran vdout1_58ck201 FIND v(dout1_58) AT=1010.025n

* CHECK dout1_59 Vdout1_59ck201 = 0.9 time = 1010
.meas tran vdout1_59ck201 FIND v(dout1_59) AT=1010.025n

* CHECK dout1_60 Vdout1_60ck201 = 0.9 time = 1010
.meas tran vdout1_60ck201 FIND v(dout1_60) AT=1010.025n

* CHECK dout1_61 Vdout1_61ck201 = 0 time = 1010
.meas tran vdout1_61ck201 FIND v(dout1_61) AT=1010.025n

* CHECK dout1_62 Vdout1_62ck201 = 0.9 time = 1010
.meas tran vdout1_62ck201 FIND v(dout1_62) AT=1010.025n

* CHECK dout1_63 Vdout1_63ck201 = 0 time = 1010
.meas tran vdout1_63ck201 FIND v(dout1_63) AT=1010.025n

* CHECK dout1_64 Vdout1_64ck201 = 0.9 time = 1010
.meas tran vdout1_64ck201 FIND v(dout1_64) AT=1010.025n

* CHECK dout1_65 Vdout1_65ck201 = 0 time = 1010
.meas tran vdout1_65ck201 FIND v(dout1_65) AT=1010.025n

* CHECK dout1_66 Vdout1_66ck201 = 0 time = 1010
.meas tran vdout1_66ck201 FIND v(dout1_66) AT=1010.025n

* CHECK dout1_67 Vdout1_67ck201 = 0.9 time = 1010
.meas tran vdout1_67ck201 FIND v(dout1_67) AT=1010.025n

* CHECK dout1_68 Vdout1_68ck201 = 0 time = 1010
.meas tran vdout1_68ck201 FIND v(dout1_68) AT=1010.025n

* CHECK dout1_69 Vdout1_69ck201 = 0.9 time = 1010
.meas tran vdout1_69ck201 FIND v(dout1_69) AT=1010.025n

* CHECK dout1_70 Vdout1_70ck201 = 0.9 time = 1010
.meas tran vdout1_70ck201 FIND v(dout1_70) AT=1010.025n

* CHECK dout1_71 Vdout1_71ck201 = 0.9 time = 1010
.meas tran vdout1_71ck201 FIND v(dout1_71) AT=1010.025n

* CHECK dout1_72 Vdout1_72ck201 = 0.9 time = 1010
.meas tran vdout1_72ck201 FIND v(dout1_72) AT=1010.025n

* CHECK dout1_73 Vdout1_73ck201 = 0.9 time = 1010
.meas tran vdout1_73ck201 FIND v(dout1_73) AT=1010.025n

* CHECK dout1_74 Vdout1_74ck201 = 0 time = 1010
.meas tran vdout1_74ck201 FIND v(dout1_74) AT=1010.025n

* CHECK dout1_75 Vdout1_75ck201 = 0.9 time = 1010
.meas tran vdout1_75ck201 FIND v(dout1_75) AT=1010.025n

* CHECK dout1_76 Vdout1_76ck201 = 0 time = 1010
.meas tran vdout1_76ck201 FIND v(dout1_76) AT=1010.025n

* CHECK dout1_77 Vdout1_77ck201 = 0.9 time = 1010
.meas tran vdout1_77ck201 FIND v(dout1_77) AT=1010.025n

* CHECK dout1_78 Vdout1_78ck201 = 0.9 time = 1010
.meas tran vdout1_78ck201 FIND v(dout1_78) AT=1010.025n

* CHECK dout1_79 Vdout1_79ck201 = 0.9 time = 1010
.meas tran vdout1_79ck201 FIND v(dout1_79) AT=1010.025n

* CHECK dout1_80 Vdout1_80ck201 = 0.9 time = 1010
.meas tran vdout1_80ck201 FIND v(dout1_80) AT=1010.025n

* CHECK dout1_81 Vdout1_81ck201 = 0 time = 1010
.meas tran vdout1_81ck201 FIND v(dout1_81) AT=1010.025n

* CHECK dout1_82 Vdout1_82ck201 = 0 time = 1010
.meas tran vdout1_82ck201 FIND v(dout1_82) AT=1010.025n

* CHECK dout1_83 Vdout1_83ck201 = 0.9 time = 1010
.meas tran vdout1_83ck201 FIND v(dout1_83) AT=1010.025n

* CHECK dout1_84 Vdout1_84ck201 = 0 time = 1010
.meas tran vdout1_84ck201 FIND v(dout1_84) AT=1010.025n

* CHECK dout1_85 Vdout1_85ck201 = 0.9 time = 1010
.meas tran vdout1_85ck201 FIND v(dout1_85) AT=1010.025n

* CHECK dout1_86 Vdout1_86ck201 = 0.9 time = 1010
.meas tran vdout1_86ck201 FIND v(dout1_86) AT=1010.025n

* CHECK dout1_87 Vdout1_87ck201 = 0.9 time = 1010
.meas tran vdout1_87ck201 FIND v(dout1_87) AT=1010.025n

* CHECK dout1_88 Vdout1_88ck201 = 0.9 time = 1010
.meas tran vdout1_88ck201 FIND v(dout1_88) AT=1010.025n

* CHECK dout1_89 Vdout1_89ck201 = 0.9 time = 1010
.meas tran vdout1_89ck201 FIND v(dout1_89) AT=1010.025n

* CHECK dout1_90 Vdout1_90ck201 = 0.9 time = 1010
.meas tran vdout1_90ck201 FIND v(dout1_90) AT=1010.025n

* CHECK dout1_91 Vdout1_91ck201 = 0 time = 1010
.meas tran vdout1_91ck201 FIND v(dout1_91) AT=1010.025n

* CHECK dout1_92 Vdout1_92ck201 = 0.9 time = 1010
.meas tran vdout1_92ck201 FIND v(dout1_92) AT=1010.025n

* CHECK dout1_93 Vdout1_93ck201 = 0.9 time = 1010
.meas tran vdout1_93ck201 FIND v(dout1_93) AT=1010.025n

* CHECK dout1_94 Vdout1_94ck201 = 0.9 time = 1010
.meas tran vdout1_94ck201 FIND v(dout1_94) AT=1010.025n

* CHECK dout1_95 Vdout1_95ck201 = 0.9 time = 1010
.meas tran vdout1_95ck201 FIND v(dout1_95) AT=1010.025n

* CHECK dout1_96 Vdout1_96ck201 = 0.9 time = 1010
.meas tran vdout1_96ck201 FIND v(dout1_96) AT=1010.025n

* CHECK dout1_97 Vdout1_97ck201 = 0.9 time = 1010
.meas tran vdout1_97ck201 FIND v(dout1_97) AT=1010.025n

* CHECK dout1_98 Vdout1_98ck201 = 0.9 time = 1010
.meas tran vdout1_98ck201 FIND v(dout1_98) AT=1010.025n

* CHECK dout1_99 Vdout1_99ck201 = 0 time = 1010
.meas tran vdout1_99ck201 FIND v(dout1_99) AT=1010.025n

* CHECK dout1_100 Vdout1_100ck201 = 0.9 time = 1010
.meas tran vdout1_100ck201 FIND v(dout1_100) AT=1010.025n

* CHECK dout1_101 Vdout1_101ck201 = 0.9 time = 1010
.meas tran vdout1_101ck201 FIND v(dout1_101) AT=1010.025n

* CHECK dout1_102 Vdout1_102ck201 = 0 time = 1010
.meas tran vdout1_102ck201 FIND v(dout1_102) AT=1010.025n

* CHECK dout1_103 Vdout1_103ck201 = 0 time = 1010
.meas tran vdout1_103ck201 FIND v(dout1_103) AT=1010.025n

* CHECK dout1_104 Vdout1_104ck201 = 0.9 time = 1010
.meas tran vdout1_104ck201 FIND v(dout1_104) AT=1010.025n

* CHECK dout1_105 Vdout1_105ck201 = 0.9 time = 1010
.meas tran vdout1_105ck201 FIND v(dout1_105) AT=1010.025n

* CHECK dout1_106 Vdout1_106ck201 = 0 time = 1010
.meas tran vdout1_106ck201 FIND v(dout1_106) AT=1010.025n

* CHECK dout1_107 Vdout1_107ck201 = 0 time = 1010
.meas tran vdout1_107ck201 FIND v(dout1_107) AT=1010.025n

* CHECK dout1_108 Vdout1_108ck201 = 0 time = 1010
.meas tran vdout1_108ck201 FIND v(dout1_108) AT=1010.025n

* CHECK dout1_109 Vdout1_109ck201 = 0 time = 1010
.meas tran vdout1_109ck201 FIND v(dout1_109) AT=1010.025n

* CHECK dout1_110 Vdout1_110ck201 = 0 time = 1010
.meas tran vdout1_110ck201 FIND v(dout1_110) AT=1010.025n

* CHECK dout1_111 Vdout1_111ck201 = 0 time = 1010
.meas tran vdout1_111ck201 FIND v(dout1_111) AT=1010.025n

* CHECK dout1_112 Vdout1_112ck201 = 0 time = 1010
.meas tran vdout1_112ck201 FIND v(dout1_112) AT=1010.025n

* CHECK dout1_113 Vdout1_113ck201 = 0 time = 1010
.meas tran vdout1_113ck201 FIND v(dout1_113) AT=1010.025n

* CHECK dout1_114 Vdout1_114ck201 = 0 time = 1010
.meas tran vdout1_114ck201 FIND v(dout1_114) AT=1010.025n

* CHECK dout1_115 Vdout1_115ck201 = 0 time = 1010
.meas tran vdout1_115ck201 FIND v(dout1_115) AT=1010.025n

* CHECK dout1_116 Vdout1_116ck201 = 0.9 time = 1010
.meas tran vdout1_116ck201 FIND v(dout1_116) AT=1010.025n

* CHECK dout1_117 Vdout1_117ck201 = 0 time = 1010
.meas tran vdout1_117ck201 FIND v(dout1_117) AT=1010.025n

* CHECK dout1_118 Vdout1_118ck201 = 0 time = 1010
.meas tran vdout1_118ck201 FIND v(dout1_118) AT=1010.025n

* CHECK dout1_119 Vdout1_119ck201 = 0.9 time = 1010
.meas tran vdout1_119ck201 FIND v(dout1_119) AT=1010.025n

* CHECK dout1_0 Vdout1_0ck202 = 0.9 time = 1015
.meas tran vdout1_0ck202 FIND v(dout1_0) AT=1015.025n

* CHECK dout1_1 Vdout1_1ck202 = 0.9 time = 1015
.meas tran vdout1_1ck202 FIND v(dout1_1) AT=1015.025n

* CHECK dout1_2 Vdout1_2ck202 = 0.9 time = 1015
.meas tran vdout1_2ck202 FIND v(dout1_2) AT=1015.025n

* CHECK dout1_3 Vdout1_3ck202 = 0 time = 1015
.meas tran vdout1_3ck202 FIND v(dout1_3) AT=1015.025n

* CHECK dout1_4 Vdout1_4ck202 = 0.9 time = 1015
.meas tran vdout1_4ck202 FIND v(dout1_4) AT=1015.025n

* CHECK dout1_5 Vdout1_5ck202 = 0 time = 1015
.meas tran vdout1_5ck202 FIND v(dout1_5) AT=1015.025n

* CHECK dout1_6 Vdout1_6ck202 = 0.9 time = 1015
.meas tran vdout1_6ck202 FIND v(dout1_6) AT=1015.025n

* CHECK dout1_7 Vdout1_7ck202 = 0 time = 1015
.meas tran vdout1_7ck202 FIND v(dout1_7) AT=1015.025n

* CHECK dout1_8 Vdout1_8ck202 = 0 time = 1015
.meas tran vdout1_8ck202 FIND v(dout1_8) AT=1015.025n

* CHECK dout1_9 Vdout1_9ck202 = 0.9 time = 1015
.meas tran vdout1_9ck202 FIND v(dout1_9) AT=1015.025n

* CHECK dout1_10 Vdout1_10ck202 = 0 time = 1015
.meas tran vdout1_10ck202 FIND v(dout1_10) AT=1015.025n

* CHECK dout1_11 Vdout1_11ck202 = 0 time = 1015
.meas tran vdout1_11ck202 FIND v(dout1_11) AT=1015.025n

* CHECK dout1_12 Vdout1_12ck202 = 0 time = 1015
.meas tran vdout1_12ck202 FIND v(dout1_12) AT=1015.025n

* CHECK dout1_13 Vdout1_13ck202 = 0 time = 1015
.meas tran vdout1_13ck202 FIND v(dout1_13) AT=1015.025n

* CHECK dout1_14 Vdout1_14ck202 = 0 time = 1015
.meas tran vdout1_14ck202 FIND v(dout1_14) AT=1015.025n

* CHECK dout1_15 Vdout1_15ck202 = 0 time = 1015
.meas tran vdout1_15ck202 FIND v(dout1_15) AT=1015.025n

* CHECK dout1_16 Vdout1_16ck202 = 0.9 time = 1015
.meas tran vdout1_16ck202 FIND v(dout1_16) AT=1015.025n

* CHECK dout1_17 Vdout1_17ck202 = 0 time = 1015
.meas tran vdout1_17ck202 FIND v(dout1_17) AT=1015.025n

* CHECK dout1_18 Vdout1_18ck202 = 0.9 time = 1015
.meas tran vdout1_18ck202 FIND v(dout1_18) AT=1015.025n

* CHECK dout1_19 Vdout1_19ck202 = 0.9 time = 1015
.meas tran vdout1_19ck202 FIND v(dout1_19) AT=1015.025n

* CHECK dout1_20 Vdout1_20ck202 = 0 time = 1015
.meas tran vdout1_20ck202 FIND v(dout1_20) AT=1015.025n

* CHECK dout1_21 Vdout1_21ck202 = 0.9 time = 1015
.meas tran vdout1_21ck202 FIND v(dout1_21) AT=1015.025n

* CHECK dout1_22 Vdout1_22ck202 = 0.9 time = 1015
.meas tran vdout1_22ck202 FIND v(dout1_22) AT=1015.025n

* CHECK dout1_23 Vdout1_23ck202 = 0.9 time = 1015
.meas tran vdout1_23ck202 FIND v(dout1_23) AT=1015.025n

* CHECK dout1_24 Vdout1_24ck202 = 0.9 time = 1015
.meas tran vdout1_24ck202 FIND v(dout1_24) AT=1015.025n

* CHECK dout1_25 Vdout1_25ck202 = 0 time = 1015
.meas tran vdout1_25ck202 FIND v(dout1_25) AT=1015.025n

* CHECK dout1_26 Vdout1_26ck202 = 0 time = 1015
.meas tran vdout1_26ck202 FIND v(dout1_26) AT=1015.025n

* CHECK dout1_27 Vdout1_27ck202 = 0 time = 1015
.meas tran vdout1_27ck202 FIND v(dout1_27) AT=1015.025n

* CHECK dout1_28 Vdout1_28ck202 = 0.9 time = 1015
.meas tran vdout1_28ck202 FIND v(dout1_28) AT=1015.025n

* CHECK dout1_29 Vdout1_29ck202 = 0.9 time = 1015
.meas tran vdout1_29ck202 FIND v(dout1_29) AT=1015.025n

* CHECK dout1_30 Vdout1_30ck202 = 0 time = 1015
.meas tran vdout1_30ck202 FIND v(dout1_30) AT=1015.025n

* CHECK dout1_31 Vdout1_31ck202 = 0 time = 1015
.meas tran vdout1_31ck202 FIND v(dout1_31) AT=1015.025n

* CHECK dout1_32 Vdout1_32ck202 = 0 time = 1015
.meas tran vdout1_32ck202 FIND v(dout1_32) AT=1015.025n

* CHECK dout1_33 Vdout1_33ck202 = 0 time = 1015
.meas tran vdout1_33ck202 FIND v(dout1_33) AT=1015.025n

* CHECK dout1_34 Vdout1_34ck202 = 0 time = 1015
.meas tran vdout1_34ck202 FIND v(dout1_34) AT=1015.025n

* CHECK dout1_35 Vdout1_35ck202 = 0 time = 1015
.meas tran vdout1_35ck202 FIND v(dout1_35) AT=1015.025n

* CHECK dout1_36 Vdout1_36ck202 = 0.9 time = 1015
.meas tran vdout1_36ck202 FIND v(dout1_36) AT=1015.025n

* CHECK dout1_37 Vdout1_37ck202 = 0 time = 1015
.meas tran vdout1_37ck202 FIND v(dout1_37) AT=1015.025n

* CHECK dout1_38 Vdout1_38ck202 = 0.9 time = 1015
.meas tran vdout1_38ck202 FIND v(dout1_38) AT=1015.025n

* CHECK dout1_39 Vdout1_39ck202 = 0.9 time = 1015
.meas tran vdout1_39ck202 FIND v(dout1_39) AT=1015.025n

* CHECK dout1_40 Vdout1_40ck202 = 0.9 time = 1015
.meas tran vdout1_40ck202 FIND v(dout1_40) AT=1015.025n

* CHECK dout1_41 Vdout1_41ck202 = 0.9 time = 1015
.meas tran vdout1_41ck202 FIND v(dout1_41) AT=1015.025n

* CHECK dout1_42 Vdout1_42ck202 = 0 time = 1015
.meas tran vdout1_42ck202 FIND v(dout1_42) AT=1015.025n

* CHECK dout1_43 Vdout1_43ck202 = 0.9 time = 1015
.meas tran vdout1_43ck202 FIND v(dout1_43) AT=1015.025n

* CHECK dout1_44 Vdout1_44ck202 = 0.9 time = 1015
.meas tran vdout1_44ck202 FIND v(dout1_44) AT=1015.025n

* CHECK dout1_45 Vdout1_45ck202 = 0 time = 1015
.meas tran vdout1_45ck202 FIND v(dout1_45) AT=1015.025n

* CHECK dout1_46 Vdout1_46ck202 = 0 time = 1015
.meas tran vdout1_46ck202 FIND v(dout1_46) AT=1015.025n

* CHECK dout1_47 Vdout1_47ck202 = 0.9 time = 1015
.meas tran vdout1_47ck202 FIND v(dout1_47) AT=1015.025n

* CHECK dout1_48 Vdout1_48ck202 = 0 time = 1015
.meas tran vdout1_48ck202 FIND v(dout1_48) AT=1015.025n

* CHECK dout1_49 Vdout1_49ck202 = 0.9 time = 1015
.meas tran vdout1_49ck202 FIND v(dout1_49) AT=1015.025n

* CHECK dout1_50 Vdout1_50ck202 = 0 time = 1015
.meas tran vdout1_50ck202 FIND v(dout1_50) AT=1015.025n

* CHECK dout1_51 Vdout1_51ck202 = 0 time = 1015
.meas tran vdout1_51ck202 FIND v(dout1_51) AT=1015.025n

* CHECK dout1_52 Vdout1_52ck202 = 0.9 time = 1015
.meas tran vdout1_52ck202 FIND v(dout1_52) AT=1015.025n

* CHECK dout1_53 Vdout1_53ck202 = 0 time = 1015
.meas tran vdout1_53ck202 FIND v(dout1_53) AT=1015.025n

* CHECK dout1_54 Vdout1_54ck202 = 0.9 time = 1015
.meas tran vdout1_54ck202 FIND v(dout1_54) AT=1015.025n

* CHECK dout1_55 Vdout1_55ck202 = 0 time = 1015
.meas tran vdout1_55ck202 FIND v(dout1_55) AT=1015.025n

* CHECK dout1_56 Vdout1_56ck202 = 0 time = 1015
.meas tran vdout1_56ck202 FIND v(dout1_56) AT=1015.025n

* CHECK dout1_57 Vdout1_57ck202 = 0 time = 1015
.meas tran vdout1_57ck202 FIND v(dout1_57) AT=1015.025n

* CHECK dout1_58 Vdout1_58ck202 = 0.9 time = 1015
.meas tran vdout1_58ck202 FIND v(dout1_58) AT=1015.025n

* CHECK dout1_59 Vdout1_59ck202 = 0 time = 1015
.meas tran vdout1_59ck202 FIND v(dout1_59) AT=1015.025n

* CHECK dout1_60 Vdout1_60ck202 = 0.9 time = 1015
.meas tran vdout1_60ck202 FIND v(dout1_60) AT=1015.025n

* CHECK dout1_61 Vdout1_61ck202 = 0 time = 1015
.meas tran vdout1_61ck202 FIND v(dout1_61) AT=1015.025n

* CHECK dout1_62 Vdout1_62ck202 = 0.9 time = 1015
.meas tran vdout1_62ck202 FIND v(dout1_62) AT=1015.025n

* CHECK dout1_63 Vdout1_63ck202 = 0 time = 1015
.meas tran vdout1_63ck202 FIND v(dout1_63) AT=1015.025n

* CHECK dout1_64 Vdout1_64ck202 = 0.9 time = 1015
.meas tran vdout1_64ck202 FIND v(dout1_64) AT=1015.025n

* CHECK dout1_65 Vdout1_65ck202 = 0 time = 1015
.meas tran vdout1_65ck202 FIND v(dout1_65) AT=1015.025n

* CHECK dout1_66 Vdout1_66ck202 = 0 time = 1015
.meas tran vdout1_66ck202 FIND v(dout1_66) AT=1015.025n

* CHECK dout1_67 Vdout1_67ck202 = 0 time = 1015
.meas tran vdout1_67ck202 FIND v(dout1_67) AT=1015.025n

* CHECK dout1_68 Vdout1_68ck202 = 0.9 time = 1015
.meas tran vdout1_68ck202 FIND v(dout1_68) AT=1015.025n

* CHECK dout1_69 Vdout1_69ck202 = 0 time = 1015
.meas tran vdout1_69ck202 FIND v(dout1_69) AT=1015.025n

* CHECK dout1_70 Vdout1_70ck202 = 0.9 time = 1015
.meas tran vdout1_70ck202 FIND v(dout1_70) AT=1015.025n

* CHECK dout1_71 Vdout1_71ck202 = 0 time = 1015
.meas tran vdout1_71ck202 FIND v(dout1_71) AT=1015.025n

* CHECK dout1_72 Vdout1_72ck202 = 0 time = 1015
.meas tran vdout1_72ck202 FIND v(dout1_72) AT=1015.025n

* CHECK dout1_73 Vdout1_73ck202 = 0.9 time = 1015
.meas tran vdout1_73ck202 FIND v(dout1_73) AT=1015.025n

* CHECK dout1_74 Vdout1_74ck202 = 0 time = 1015
.meas tran vdout1_74ck202 FIND v(dout1_74) AT=1015.025n

* CHECK dout1_75 Vdout1_75ck202 = 0 time = 1015
.meas tran vdout1_75ck202 FIND v(dout1_75) AT=1015.025n

* CHECK dout1_76 Vdout1_76ck202 = 0.9 time = 1015
.meas tran vdout1_76ck202 FIND v(dout1_76) AT=1015.025n

* CHECK dout1_77 Vdout1_77ck202 = 0.9 time = 1015
.meas tran vdout1_77ck202 FIND v(dout1_77) AT=1015.025n

* CHECK dout1_78 Vdout1_78ck202 = 0 time = 1015
.meas tran vdout1_78ck202 FIND v(dout1_78) AT=1015.025n

* CHECK dout1_79 Vdout1_79ck202 = 0 time = 1015
.meas tran vdout1_79ck202 FIND v(dout1_79) AT=1015.025n

* CHECK dout1_80 Vdout1_80ck202 = 0 time = 1015
.meas tran vdout1_80ck202 FIND v(dout1_80) AT=1015.025n

* CHECK dout1_81 Vdout1_81ck202 = 0.9 time = 1015
.meas tran vdout1_81ck202 FIND v(dout1_81) AT=1015.025n

* CHECK dout1_82 Vdout1_82ck202 = 0 time = 1015
.meas tran vdout1_82ck202 FIND v(dout1_82) AT=1015.025n

* CHECK dout1_83 Vdout1_83ck202 = 0 time = 1015
.meas tran vdout1_83ck202 FIND v(dout1_83) AT=1015.025n

* CHECK dout1_84 Vdout1_84ck202 = 0 time = 1015
.meas tran vdout1_84ck202 FIND v(dout1_84) AT=1015.025n

* CHECK dout1_85 Vdout1_85ck202 = 0.9 time = 1015
.meas tran vdout1_85ck202 FIND v(dout1_85) AT=1015.025n

* CHECK dout1_86 Vdout1_86ck202 = 0.9 time = 1015
.meas tran vdout1_86ck202 FIND v(dout1_86) AT=1015.025n

* CHECK dout1_87 Vdout1_87ck202 = 0.9 time = 1015
.meas tran vdout1_87ck202 FIND v(dout1_87) AT=1015.025n

* CHECK dout1_88 Vdout1_88ck202 = 0.9 time = 1015
.meas tran vdout1_88ck202 FIND v(dout1_88) AT=1015.025n

* CHECK dout1_89 Vdout1_89ck202 = 0 time = 1015
.meas tran vdout1_89ck202 FIND v(dout1_89) AT=1015.025n

* CHECK dout1_90 Vdout1_90ck202 = 0.9 time = 1015
.meas tran vdout1_90ck202 FIND v(dout1_90) AT=1015.025n

* CHECK dout1_91 Vdout1_91ck202 = 0.9 time = 1015
.meas tran vdout1_91ck202 FIND v(dout1_91) AT=1015.025n

* CHECK dout1_92 Vdout1_92ck202 = 0.9 time = 1015
.meas tran vdout1_92ck202 FIND v(dout1_92) AT=1015.025n

* CHECK dout1_93 Vdout1_93ck202 = 0 time = 1015
.meas tran vdout1_93ck202 FIND v(dout1_93) AT=1015.025n

* CHECK dout1_94 Vdout1_94ck202 = 0.9 time = 1015
.meas tran vdout1_94ck202 FIND v(dout1_94) AT=1015.025n

* CHECK dout1_95 Vdout1_95ck202 = 0.9 time = 1015
.meas tran vdout1_95ck202 FIND v(dout1_95) AT=1015.025n

* CHECK dout1_96 Vdout1_96ck202 = 0 time = 1015
.meas tran vdout1_96ck202 FIND v(dout1_96) AT=1015.025n

* CHECK dout1_97 Vdout1_97ck202 = 0 time = 1015
.meas tran vdout1_97ck202 FIND v(dout1_97) AT=1015.025n

* CHECK dout1_98 Vdout1_98ck202 = 0 time = 1015
.meas tran vdout1_98ck202 FIND v(dout1_98) AT=1015.025n

* CHECK dout1_99 Vdout1_99ck202 = 0.9 time = 1015
.meas tran vdout1_99ck202 FIND v(dout1_99) AT=1015.025n

* CHECK dout1_100 Vdout1_100ck202 = 0.9 time = 1015
.meas tran vdout1_100ck202 FIND v(dout1_100) AT=1015.025n

* CHECK dout1_101 Vdout1_101ck202 = 0.9 time = 1015
.meas tran vdout1_101ck202 FIND v(dout1_101) AT=1015.025n

* CHECK dout1_102 Vdout1_102ck202 = 0.9 time = 1015
.meas tran vdout1_102ck202 FIND v(dout1_102) AT=1015.025n

* CHECK dout1_103 Vdout1_103ck202 = 0.9 time = 1015
.meas tran vdout1_103ck202 FIND v(dout1_103) AT=1015.025n

* CHECK dout1_104 Vdout1_104ck202 = 0 time = 1015
.meas tran vdout1_104ck202 FIND v(dout1_104) AT=1015.025n

* CHECK dout1_105 Vdout1_105ck202 = 0.9 time = 1015
.meas tran vdout1_105ck202 FIND v(dout1_105) AT=1015.025n

* CHECK dout1_106 Vdout1_106ck202 = 0 time = 1015
.meas tran vdout1_106ck202 FIND v(dout1_106) AT=1015.025n

* CHECK dout1_107 Vdout1_107ck202 = 0 time = 1015
.meas tran vdout1_107ck202 FIND v(dout1_107) AT=1015.025n

* CHECK dout1_108 Vdout1_108ck202 = 0.9 time = 1015
.meas tran vdout1_108ck202 FIND v(dout1_108) AT=1015.025n

* CHECK dout1_109 Vdout1_109ck202 = 0 time = 1015
.meas tran vdout1_109ck202 FIND v(dout1_109) AT=1015.025n

* CHECK dout1_110 Vdout1_110ck202 = 0.9 time = 1015
.meas tran vdout1_110ck202 FIND v(dout1_110) AT=1015.025n

* CHECK dout1_111 Vdout1_111ck202 = 0 time = 1015
.meas tran vdout1_111ck202 FIND v(dout1_111) AT=1015.025n

* CHECK dout1_112 Vdout1_112ck202 = 0 time = 1015
.meas tran vdout1_112ck202 FIND v(dout1_112) AT=1015.025n

* CHECK dout1_113 Vdout1_113ck202 = 0 time = 1015
.meas tran vdout1_113ck202 FIND v(dout1_113) AT=1015.025n

* CHECK dout1_114 Vdout1_114ck202 = 0.9 time = 1015
.meas tran vdout1_114ck202 FIND v(dout1_114) AT=1015.025n

* CHECK dout1_115 Vdout1_115ck202 = 0 time = 1015
.meas tran vdout1_115ck202 FIND v(dout1_115) AT=1015.025n

* CHECK dout1_116 Vdout1_116ck202 = 0 time = 1015
.meas tran vdout1_116ck202 FIND v(dout1_116) AT=1015.025n

* CHECK dout1_117 Vdout1_117ck202 = 0 time = 1015
.meas tran vdout1_117ck202 FIND v(dout1_117) AT=1015.025n

* CHECK dout1_118 Vdout1_118ck202 = 0.9 time = 1015
.meas tran vdout1_118ck202 FIND v(dout1_118) AT=1015.025n

* CHECK dout1_119 Vdout1_119ck202 = 0 time = 1015
.meas tran vdout1_119ck202 FIND v(dout1_119) AT=1015.025n

* CHECK dout1_0 Vdout1_0ck203 = 0 time = 1020
.meas tran vdout1_0ck203 FIND v(dout1_0) AT=1020.025n

* CHECK dout1_1 Vdout1_1ck203 = 0 time = 1020
.meas tran vdout1_1ck203 FIND v(dout1_1) AT=1020.025n

* CHECK dout1_2 Vdout1_2ck203 = 0 time = 1020
.meas tran vdout1_2ck203 FIND v(dout1_2) AT=1020.025n

* CHECK dout1_3 Vdout1_3ck203 = 0 time = 1020
.meas tran vdout1_3ck203 FIND v(dout1_3) AT=1020.025n

* CHECK dout1_4 Vdout1_4ck203 = 0.9 time = 1020
.meas tran vdout1_4ck203 FIND v(dout1_4) AT=1020.025n

* CHECK dout1_5 Vdout1_5ck203 = 0 time = 1020
.meas tran vdout1_5ck203 FIND v(dout1_5) AT=1020.025n

* CHECK dout1_6 Vdout1_6ck203 = 0 time = 1020
.meas tran vdout1_6ck203 FIND v(dout1_6) AT=1020.025n

* CHECK dout1_7 Vdout1_7ck203 = 0.9 time = 1020
.meas tran vdout1_7ck203 FIND v(dout1_7) AT=1020.025n

* CHECK dout1_8 Vdout1_8ck203 = 0.9 time = 1020
.meas tran vdout1_8ck203 FIND v(dout1_8) AT=1020.025n

* CHECK dout1_9 Vdout1_9ck203 = 0.9 time = 1020
.meas tran vdout1_9ck203 FIND v(dout1_9) AT=1020.025n

* CHECK dout1_10 Vdout1_10ck203 = 0 time = 1020
.meas tran vdout1_10ck203 FIND v(dout1_10) AT=1020.025n

* CHECK dout1_11 Vdout1_11ck203 = 0.9 time = 1020
.meas tran vdout1_11ck203 FIND v(dout1_11) AT=1020.025n

* CHECK dout1_12 Vdout1_12ck203 = 0 time = 1020
.meas tran vdout1_12ck203 FIND v(dout1_12) AT=1020.025n

* CHECK dout1_13 Vdout1_13ck203 = 0.9 time = 1020
.meas tran vdout1_13ck203 FIND v(dout1_13) AT=1020.025n

* CHECK dout1_14 Vdout1_14ck203 = 0 time = 1020
.meas tran vdout1_14ck203 FIND v(dout1_14) AT=1020.025n

* CHECK dout1_15 Vdout1_15ck203 = 0.9 time = 1020
.meas tran vdout1_15ck203 FIND v(dout1_15) AT=1020.025n

* CHECK dout1_16 Vdout1_16ck203 = 0 time = 1020
.meas tran vdout1_16ck203 FIND v(dout1_16) AT=1020.025n

* CHECK dout1_17 Vdout1_17ck203 = 0.9 time = 1020
.meas tran vdout1_17ck203 FIND v(dout1_17) AT=1020.025n

* CHECK dout1_18 Vdout1_18ck203 = 0.9 time = 1020
.meas tran vdout1_18ck203 FIND v(dout1_18) AT=1020.025n

* CHECK dout1_19 Vdout1_19ck203 = 0 time = 1020
.meas tran vdout1_19ck203 FIND v(dout1_19) AT=1020.025n

* CHECK dout1_20 Vdout1_20ck203 = 0.9 time = 1020
.meas tran vdout1_20ck203 FIND v(dout1_20) AT=1020.025n

* CHECK dout1_21 Vdout1_21ck203 = 0 time = 1020
.meas tran vdout1_21ck203 FIND v(dout1_21) AT=1020.025n

* CHECK dout1_22 Vdout1_22ck203 = 0 time = 1020
.meas tran vdout1_22ck203 FIND v(dout1_22) AT=1020.025n

* CHECK dout1_23 Vdout1_23ck203 = 0 time = 1020
.meas tran vdout1_23ck203 FIND v(dout1_23) AT=1020.025n

* CHECK dout1_24 Vdout1_24ck203 = 0 time = 1020
.meas tran vdout1_24ck203 FIND v(dout1_24) AT=1020.025n

* CHECK dout1_25 Vdout1_25ck203 = 0 time = 1020
.meas tran vdout1_25ck203 FIND v(dout1_25) AT=1020.025n

* CHECK dout1_26 Vdout1_26ck203 = 0 time = 1020
.meas tran vdout1_26ck203 FIND v(dout1_26) AT=1020.025n

* CHECK dout1_27 Vdout1_27ck203 = 0 time = 1020
.meas tran vdout1_27ck203 FIND v(dout1_27) AT=1020.025n

* CHECK dout1_28 Vdout1_28ck203 = 0 time = 1020
.meas tran vdout1_28ck203 FIND v(dout1_28) AT=1020.025n

* CHECK dout1_29 Vdout1_29ck203 = 0.9 time = 1020
.meas tran vdout1_29ck203 FIND v(dout1_29) AT=1020.025n

* CHECK dout1_30 Vdout1_30ck203 = 0 time = 1020
.meas tran vdout1_30ck203 FIND v(dout1_30) AT=1020.025n

* CHECK dout1_31 Vdout1_31ck203 = 0 time = 1020
.meas tran vdout1_31ck203 FIND v(dout1_31) AT=1020.025n

* CHECK dout1_32 Vdout1_32ck203 = 0 time = 1020
.meas tran vdout1_32ck203 FIND v(dout1_32) AT=1020.025n

* CHECK dout1_33 Vdout1_33ck203 = 0.9 time = 1020
.meas tran vdout1_33ck203 FIND v(dout1_33) AT=1020.025n

* CHECK dout1_34 Vdout1_34ck203 = 0.9 time = 1020
.meas tran vdout1_34ck203 FIND v(dout1_34) AT=1020.025n

* CHECK dout1_35 Vdout1_35ck203 = 0 time = 1020
.meas tran vdout1_35ck203 FIND v(dout1_35) AT=1020.025n

* CHECK dout1_36 Vdout1_36ck203 = 0.9 time = 1020
.meas tran vdout1_36ck203 FIND v(dout1_36) AT=1020.025n

* CHECK dout1_37 Vdout1_37ck203 = 0 time = 1020
.meas tran vdout1_37ck203 FIND v(dout1_37) AT=1020.025n

* CHECK dout1_38 Vdout1_38ck203 = 0.9 time = 1020
.meas tran vdout1_38ck203 FIND v(dout1_38) AT=1020.025n

* CHECK dout1_39 Vdout1_39ck203 = 0.9 time = 1020
.meas tran vdout1_39ck203 FIND v(dout1_39) AT=1020.025n

* CHECK dout1_40 Vdout1_40ck203 = 0.9 time = 1020
.meas tran vdout1_40ck203 FIND v(dout1_40) AT=1020.025n

* CHECK dout1_41 Vdout1_41ck203 = 0.9 time = 1020
.meas tran vdout1_41ck203 FIND v(dout1_41) AT=1020.025n

* CHECK dout1_42 Vdout1_42ck203 = 0 time = 1020
.meas tran vdout1_42ck203 FIND v(dout1_42) AT=1020.025n

* CHECK dout1_43 Vdout1_43ck203 = 0.9 time = 1020
.meas tran vdout1_43ck203 FIND v(dout1_43) AT=1020.025n

* CHECK dout1_44 Vdout1_44ck203 = 0.9 time = 1020
.meas tran vdout1_44ck203 FIND v(dout1_44) AT=1020.025n

* CHECK dout1_45 Vdout1_45ck203 = 0 time = 1020
.meas tran vdout1_45ck203 FIND v(dout1_45) AT=1020.025n

* CHECK dout1_46 Vdout1_46ck203 = 0.9 time = 1020
.meas tran vdout1_46ck203 FIND v(dout1_46) AT=1020.025n

* CHECK dout1_47 Vdout1_47ck203 = 0.9 time = 1020
.meas tran vdout1_47ck203 FIND v(dout1_47) AT=1020.025n

* CHECK dout1_48 Vdout1_48ck203 = 0.9 time = 1020
.meas tran vdout1_48ck203 FIND v(dout1_48) AT=1020.025n

* CHECK dout1_49 Vdout1_49ck203 = 0.9 time = 1020
.meas tran vdout1_49ck203 FIND v(dout1_49) AT=1020.025n

* CHECK dout1_50 Vdout1_50ck203 = 0 time = 1020
.meas tran vdout1_50ck203 FIND v(dout1_50) AT=1020.025n

* CHECK dout1_51 Vdout1_51ck203 = 0 time = 1020
.meas tran vdout1_51ck203 FIND v(dout1_51) AT=1020.025n

* CHECK dout1_52 Vdout1_52ck203 = 0.9 time = 1020
.meas tran vdout1_52ck203 FIND v(dout1_52) AT=1020.025n

* CHECK dout1_53 Vdout1_53ck203 = 0 time = 1020
.meas tran vdout1_53ck203 FIND v(dout1_53) AT=1020.025n

* CHECK dout1_54 Vdout1_54ck203 = 0.9 time = 1020
.meas tran vdout1_54ck203 FIND v(dout1_54) AT=1020.025n

* CHECK dout1_55 Vdout1_55ck203 = 0.9 time = 1020
.meas tran vdout1_55ck203 FIND v(dout1_55) AT=1020.025n

* CHECK dout1_56 Vdout1_56ck203 = 0.9 time = 1020
.meas tran vdout1_56ck203 FIND v(dout1_56) AT=1020.025n

* CHECK dout1_57 Vdout1_57ck203 = 0 time = 1020
.meas tran vdout1_57ck203 FIND v(dout1_57) AT=1020.025n

* CHECK dout1_58 Vdout1_58ck203 = 0.9 time = 1020
.meas tran vdout1_58ck203 FIND v(dout1_58) AT=1020.025n

* CHECK dout1_59 Vdout1_59ck203 = 0.9 time = 1020
.meas tran vdout1_59ck203 FIND v(dout1_59) AT=1020.025n

* CHECK dout1_60 Vdout1_60ck203 = 0.9 time = 1020
.meas tran vdout1_60ck203 FIND v(dout1_60) AT=1020.025n

* CHECK dout1_61 Vdout1_61ck203 = 0 time = 1020
.meas tran vdout1_61ck203 FIND v(dout1_61) AT=1020.025n

* CHECK dout1_62 Vdout1_62ck203 = 0.9 time = 1020
.meas tran vdout1_62ck203 FIND v(dout1_62) AT=1020.025n

* CHECK dout1_63 Vdout1_63ck203 = 0 time = 1020
.meas tran vdout1_63ck203 FIND v(dout1_63) AT=1020.025n

* CHECK dout1_64 Vdout1_64ck203 = 0.9 time = 1020
.meas tran vdout1_64ck203 FIND v(dout1_64) AT=1020.025n

* CHECK dout1_65 Vdout1_65ck203 = 0 time = 1020
.meas tran vdout1_65ck203 FIND v(dout1_65) AT=1020.025n

* CHECK dout1_66 Vdout1_66ck203 = 0 time = 1020
.meas tran vdout1_66ck203 FIND v(dout1_66) AT=1020.025n

* CHECK dout1_67 Vdout1_67ck203 = 0.9 time = 1020
.meas tran vdout1_67ck203 FIND v(dout1_67) AT=1020.025n

* CHECK dout1_68 Vdout1_68ck203 = 0 time = 1020
.meas tran vdout1_68ck203 FIND v(dout1_68) AT=1020.025n

* CHECK dout1_69 Vdout1_69ck203 = 0.9 time = 1020
.meas tran vdout1_69ck203 FIND v(dout1_69) AT=1020.025n

* CHECK dout1_70 Vdout1_70ck203 = 0.9 time = 1020
.meas tran vdout1_70ck203 FIND v(dout1_70) AT=1020.025n

* CHECK dout1_71 Vdout1_71ck203 = 0.9 time = 1020
.meas tran vdout1_71ck203 FIND v(dout1_71) AT=1020.025n

* CHECK dout1_72 Vdout1_72ck203 = 0.9 time = 1020
.meas tran vdout1_72ck203 FIND v(dout1_72) AT=1020.025n

* CHECK dout1_73 Vdout1_73ck203 = 0.9 time = 1020
.meas tran vdout1_73ck203 FIND v(dout1_73) AT=1020.025n

* CHECK dout1_74 Vdout1_74ck203 = 0 time = 1020
.meas tran vdout1_74ck203 FIND v(dout1_74) AT=1020.025n

* CHECK dout1_75 Vdout1_75ck203 = 0.9 time = 1020
.meas tran vdout1_75ck203 FIND v(dout1_75) AT=1020.025n

* CHECK dout1_76 Vdout1_76ck203 = 0 time = 1020
.meas tran vdout1_76ck203 FIND v(dout1_76) AT=1020.025n

* CHECK dout1_77 Vdout1_77ck203 = 0.9 time = 1020
.meas tran vdout1_77ck203 FIND v(dout1_77) AT=1020.025n

* CHECK dout1_78 Vdout1_78ck203 = 0.9 time = 1020
.meas tran vdout1_78ck203 FIND v(dout1_78) AT=1020.025n

* CHECK dout1_79 Vdout1_79ck203 = 0.9 time = 1020
.meas tran vdout1_79ck203 FIND v(dout1_79) AT=1020.025n

* CHECK dout1_80 Vdout1_80ck203 = 0.9 time = 1020
.meas tran vdout1_80ck203 FIND v(dout1_80) AT=1020.025n

* CHECK dout1_81 Vdout1_81ck203 = 0 time = 1020
.meas tran vdout1_81ck203 FIND v(dout1_81) AT=1020.025n

* CHECK dout1_82 Vdout1_82ck203 = 0 time = 1020
.meas tran vdout1_82ck203 FIND v(dout1_82) AT=1020.025n

* CHECK dout1_83 Vdout1_83ck203 = 0.9 time = 1020
.meas tran vdout1_83ck203 FIND v(dout1_83) AT=1020.025n

* CHECK dout1_84 Vdout1_84ck203 = 0 time = 1020
.meas tran vdout1_84ck203 FIND v(dout1_84) AT=1020.025n

* CHECK dout1_85 Vdout1_85ck203 = 0.9 time = 1020
.meas tran vdout1_85ck203 FIND v(dout1_85) AT=1020.025n

* CHECK dout1_86 Vdout1_86ck203 = 0.9 time = 1020
.meas tran vdout1_86ck203 FIND v(dout1_86) AT=1020.025n

* CHECK dout1_87 Vdout1_87ck203 = 0.9 time = 1020
.meas tran vdout1_87ck203 FIND v(dout1_87) AT=1020.025n

* CHECK dout1_88 Vdout1_88ck203 = 0.9 time = 1020
.meas tran vdout1_88ck203 FIND v(dout1_88) AT=1020.025n

* CHECK dout1_89 Vdout1_89ck203 = 0.9 time = 1020
.meas tran vdout1_89ck203 FIND v(dout1_89) AT=1020.025n

* CHECK dout1_90 Vdout1_90ck203 = 0.9 time = 1020
.meas tran vdout1_90ck203 FIND v(dout1_90) AT=1020.025n

* CHECK dout1_91 Vdout1_91ck203 = 0 time = 1020
.meas tran vdout1_91ck203 FIND v(dout1_91) AT=1020.025n

* CHECK dout1_92 Vdout1_92ck203 = 0.9 time = 1020
.meas tran vdout1_92ck203 FIND v(dout1_92) AT=1020.025n

* CHECK dout1_93 Vdout1_93ck203 = 0.9 time = 1020
.meas tran vdout1_93ck203 FIND v(dout1_93) AT=1020.025n

* CHECK dout1_94 Vdout1_94ck203 = 0.9 time = 1020
.meas tran vdout1_94ck203 FIND v(dout1_94) AT=1020.025n

* CHECK dout1_95 Vdout1_95ck203 = 0.9 time = 1020
.meas tran vdout1_95ck203 FIND v(dout1_95) AT=1020.025n

* CHECK dout1_96 Vdout1_96ck203 = 0.9 time = 1020
.meas tran vdout1_96ck203 FIND v(dout1_96) AT=1020.025n

* CHECK dout1_97 Vdout1_97ck203 = 0.9 time = 1020
.meas tran vdout1_97ck203 FIND v(dout1_97) AT=1020.025n

* CHECK dout1_98 Vdout1_98ck203 = 0.9 time = 1020
.meas tran vdout1_98ck203 FIND v(dout1_98) AT=1020.025n

* CHECK dout1_99 Vdout1_99ck203 = 0 time = 1020
.meas tran vdout1_99ck203 FIND v(dout1_99) AT=1020.025n

* CHECK dout1_100 Vdout1_100ck203 = 0.9 time = 1020
.meas tran vdout1_100ck203 FIND v(dout1_100) AT=1020.025n

* CHECK dout1_101 Vdout1_101ck203 = 0.9 time = 1020
.meas tran vdout1_101ck203 FIND v(dout1_101) AT=1020.025n

* CHECK dout1_102 Vdout1_102ck203 = 0 time = 1020
.meas tran vdout1_102ck203 FIND v(dout1_102) AT=1020.025n

* CHECK dout1_103 Vdout1_103ck203 = 0 time = 1020
.meas tran vdout1_103ck203 FIND v(dout1_103) AT=1020.025n

* CHECK dout1_104 Vdout1_104ck203 = 0.9 time = 1020
.meas tran vdout1_104ck203 FIND v(dout1_104) AT=1020.025n

* CHECK dout1_105 Vdout1_105ck203 = 0.9 time = 1020
.meas tran vdout1_105ck203 FIND v(dout1_105) AT=1020.025n

* CHECK dout1_106 Vdout1_106ck203 = 0 time = 1020
.meas tran vdout1_106ck203 FIND v(dout1_106) AT=1020.025n

* CHECK dout1_107 Vdout1_107ck203 = 0 time = 1020
.meas tran vdout1_107ck203 FIND v(dout1_107) AT=1020.025n

* CHECK dout1_108 Vdout1_108ck203 = 0 time = 1020
.meas tran vdout1_108ck203 FIND v(dout1_108) AT=1020.025n

* CHECK dout1_109 Vdout1_109ck203 = 0 time = 1020
.meas tran vdout1_109ck203 FIND v(dout1_109) AT=1020.025n

* CHECK dout1_110 Vdout1_110ck203 = 0 time = 1020
.meas tran vdout1_110ck203 FIND v(dout1_110) AT=1020.025n

* CHECK dout1_111 Vdout1_111ck203 = 0 time = 1020
.meas tran vdout1_111ck203 FIND v(dout1_111) AT=1020.025n

* CHECK dout1_112 Vdout1_112ck203 = 0 time = 1020
.meas tran vdout1_112ck203 FIND v(dout1_112) AT=1020.025n

* CHECK dout1_113 Vdout1_113ck203 = 0 time = 1020
.meas tran vdout1_113ck203 FIND v(dout1_113) AT=1020.025n

* CHECK dout1_114 Vdout1_114ck203 = 0 time = 1020
.meas tran vdout1_114ck203 FIND v(dout1_114) AT=1020.025n

* CHECK dout1_115 Vdout1_115ck203 = 0 time = 1020
.meas tran vdout1_115ck203 FIND v(dout1_115) AT=1020.025n

* CHECK dout1_116 Vdout1_116ck203 = 0.9 time = 1020
.meas tran vdout1_116ck203 FIND v(dout1_116) AT=1020.025n

* CHECK dout1_117 Vdout1_117ck203 = 0 time = 1020
.meas tran vdout1_117ck203 FIND v(dout1_117) AT=1020.025n

* CHECK dout1_118 Vdout1_118ck203 = 0 time = 1020
.meas tran vdout1_118ck203 FIND v(dout1_118) AT=1020.025n

* CHECK dout1_119 Vdout1_119ck203 = 0.9 time = 1020
.meas tran vdout1_119ck203 FIND v(dout1_119) AT=1020.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
